/*
 *    trac345_badssls.c
 *
 * Reference Trac #345
 * Based off of "sslcert_echo.py" provided by Eden Cohen
 *
 * Copyright 2025 DigiCert Project Authors. All Rights Reserved.
 * 
 * DigiCert® TrustCore and TrustEdge are licensed under a dual-license model:
 * - **Open Source License**: GNU AGPL v3. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE
 * - **Commercial License**: Available under DigiCert’s Master Services Agreement. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE_COMMERCIAL.txt  
 *   or https://www.digicert.com/master-services-agreement/
 * 
 * *For commercial licensing, contact DigiCert at sales@digicert.com.*
 */

#include "../../common/moptions.h"
#include "../../common/mtypes.h"
#include "../../common/mdefs.h"
#include "../../common/merrors.h"
#include "../../common/mrtos.h"
#include "../../common/mtcp.h"
#include "../../common/mocana.h"
#include "../../common/debug_console.h"
#include "../../common/mstdlib.h"

#include <stdio.h>

#define __LOOP_SERVER__ FALSE

static sbyte4 mBreak = 0;

const ubyte4  ssl_fuzz_len  = 859;
const sbyte ssl_fuzz[]    = {
};


/*type 1 bytes*/
const ubyte4 dataLen_type = 1;
const sbyte data_type[]    = {
    0x16
};
/*ver 2 bytes*/
const ubyte4 dataLen_ver = 2;
const sbyte data_ver[]    = {
    0x03,0x01
};
/*len1 2 bytes*/
const ubyte4 dataLen_len1 = 2;
const sbyte data_len1[]    = {
    0x00, 0x4a
};
/*htype1 1 bytes*/
const ubyte4 dataLen_htype1 = 1;
const sbyte data_htype1[]    = {
    0x02
};
/*len2 3 bytes*/
const ubyte4 dataLen_len2 = 3;
const sbyte data_len2[]    = {
    0x00, 0x00, 0x46
};
/*rnd 32 bytes*/
const ubyte4 dataLen_rnd = 32;
const sbyte data_rnd[]    = {
    0x46, 0xb8, 0xbc, 0x8c, 0x2b, 0xaa, 0x5f, 0x16, 0x2f, 0xa0, 0xf2, 0xa2, 0x35, 0xe5, 0x91, 0xba,
    0xad, 0x6b, 0x06, 0xdc, 0x44, 0x2e, 0x22, 0xb9, 0x02, 0x92, 0x53, 0x26, 0x3b, 0xb3, 0xde, 0x82
};
/*len3 1 bytes*/
const ubyte4 dataLen_len3 = 1;
const sbyte data_len3[]    = {
    0x20
};
/*senID 32 bytes*/
const ubyte4 dataLen_senID = 32;
const sbyte data_senID[]    = {
    0xc9, 0xd3, 0xf3, 0xba, 0x95, 0x74, 0xef, 0x9c, 0xbf, 0x09, 0xc4, 0x89, 0xc1, 0xfa, 0xbe, 0xa9,
    0xe6, 0x3b, 0xab, 0xcd, 0xb2, 0x13, 0xed, 0x49, 0xd3, 0xbc, 0xe8, 0x4c, 0x54, 0xe5, 0x47, 0x5c
};
/*cipher 2 bytes*/
const ubyte4 dataLen_cipher = 2;
const sbyte data_cipher[]    = {
    0x00, 0x2f
};
/*comp 1 bytes*/
const ubyte4 dataLen_comp = 1;
const sbyte data_comp[]    = {
    0x00
};
/*len4 2 bytes*/
const ubyte4 dataLen_len4 = 2;
const sbyte data_len4[]    = {
    0x03, 0x04
};
/*htype2 1 bytes*/
const ubyte4 dataLen_htype2 = 1;
const sbyte data_htype2[]    = {
    0x0b
};
/*len5 3 bytes*/
const ubyte4 dataLen_len5 = 3;
const sbyte data_len5[]    = {
    0x00, 0x03, 0x00
};
/*len8 3 bytes*/
const ubyte4 dataLen_len8 = 3;
const sbyte data_len8[]    = {
    0x20, 0x02, 0xfd
};
/*cert 765 bytes*/
const ubyte4 dataLen_cert = 765;
const sbyte data_cert[]    = {
    0x00, 0x02, 0xfa, 0x30, 0x82, 0x02, 0xf6, 0x30, 0x82, 0x01, 0xde, 0xa0, 0x03, 0x02, 0x01, 0x02,
    0x02, 0x04, 0x10, 0x54, 0x94, 0x62, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d,
    0x01, 0x01, 0x05, 0x05, 0x00, 0x30, 0x32, 0x31, 0x0b, 0x30, 0x09, 0x06, 0x03, 0x55, 0x04, 0x06,
    0x13, 0x02, 0x55, 0x53, 0x31, 0x0e, 0x30, 0x0c, 0x06, 0x03, 0x55, 0x04, 0x0a, 0x13, 0x05, 0x69,
    0x6e, 0x74, 0x65, 0x6c, 0x31, 0x13, 0x30, 0x11, 0x06, 0x03, 0x55, 0x04, 0x03, 0x13, 0x0a, 0x43,
    0x49, 0x52, 0x41, 0x73, 0x77, 0x69, 0x74, 0x63, 0x68, 0x30, 0x1e, 0x17, 0x0d, 0x30, 0x37, 0x30,
    0x37, 0x32, 0x35, 0x30, 0x31, 0x34, 0x38, 0x34, 0x31, 0x5a, 0x17, 0x0d, 0x32, 0x37, 0x30, 0x37,
    0x32, 0x30, 0x30, 0x31, 0x34, 0x38, 0x34, 0x31, 0x5a, 0x30, 0x78, 0x31, 0x0b, 0x30, 0x09, 0x06,
    0x03, 0x55, 0x04, 0x06, 0x13, 0x02, 0x55, 0x53, 0x31, 0x1c, 0x30, 0x1a, 0x06, 0x03, 0x55, 0x04,
    0x0a, 0x13, 0x13, 0x53, 0x61, 0x6d, 0x70, 0x6c, 0x65, 0x20, 0x4f, 0x72, 0x67, 0x61, 0x6e, 0x69,
    0x7a, 0x61, 0x74, 0x69, 0x6f, 0x6e, 0x31, 0x2a, 0x30, 0x28, 0x06, 0x03, 0x55, 0x04, 0x0b, 0x13,
    0x21, 0x49, 0x6e, 0x74, 0x65, 0x6c, 0x28, 0x52, 0x29, 0x20, 0x43, 0x6c, 0x69, 0x65, 0x6e, 0x74,
    0x20, 0x53, 0x65, 0x74, 0x75, 0x70, 0x20, 0x43, 0x65, 0x72, 0x74, 0x69, 0x66, 0x69, 0x63, 0x61,
    0x74, 0x65, 0x31, 0x1f, 0x30, 0x1d, 0x06, 0x03, 0x55, 0x04, 0x03, 0x13, 0x16, 0x73, 0x76, 0x6c,
    0x78, 0x35, 0x33, 0x39, 0x2e, 0x6e, 0x61, 0x63, 0x74, 0x65, 0x73, 0x74, 0x69, 0x6e, 0x67, 0x2e,
    0x63, 0x6f, 0x6d, 0x30, 0x81, 0x9f, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d,
    0x01, 0x01, 0x01, 0x05, 0x00, 0x03, 0x81, 0x8d, 0x00, 0x30, 0x81, 0x89, 0x02, 0x81, 0x81, 0x00,
    0xaa, 0xc0, 0x9a, 0x3f, 0xda, 0x32, 0xa4, 0xd2, 0xec, 0xa4, 0xa6, 0x70, 0xb6, 0x16, 0x39, 0x9d,
    0x80, 0x92, 0x56, 0x49, 0xa0, 0x42, 0x70, 0x7b, 0x21, 0x73, 0x8b, 0x22, 0x60, 0x75, 0xf8, 0x01,
    0x47, 0xc2, 0x9d, 0xb9, 0xa2, 0x29, 0x1e, 0x55, 0xab, 0x2f, 0x21, 0x28, 0x57, 0xe0, 0xaa, 0x64,
    0xda, 0x6c, 0xca, 0x0c, 0x4e, 0xac, 0x77, 0xfc, 0x6b, 0xeb, 0xcb, 0x04, 0x26, 0x42, 0x3f, 0xa1,
    0xb1, 0x62, 0xba, 0x38, 0xe0, 0x14, 0xab, 0xb4, 0x3e, 0x5b, 0x4e, 0x41, 0x1e, 0x73, 0xf1, 0x1a,
    0x4c, 0xd7, 0xe4, 0xbf, 0x1c, 0xc7, 0xa6, 0x0d, 0x58, 0xe0, 0x95, 0x75, 0xeb, 0xe1, 0xcf, 0x67,
    0x7f, 0xe6, 0xc0, 0x56, 0x70, 0x7b, 0x99, 0xb9, 0xf2, 0xa4, 0xe9, 0xf4, 0xe0, 0xd5, 0x9a, 0x04,
    0x9b, 0x52, 0xfa, 0x63, 0x2b, 0x4a, 0x9f, 0x9a, 0xfe, 0xfb, 0xe1, 0x2d, 0x29, 0x45, 0x60, 0xd7,
    0x02, 0x03, 0x01, 0x00, 0x01, 0xa3, 0x52, 0x30, 0x50, 0x30, 0x41, 0x06, 0x03, 0x55, 0x1d, 0x25,
    0x04, 0x3a, 0x30, 0x38, 0x06, 0x08, 0x2b, 0x06, 0x01, 0x05, 0x05, 0x07, 0x03, 0x01, 0x06, 0x08,
    0x2b, 0x06, 0x01, 0x05, 0x05, 0x07, 0x03, 0x02, 0x06, 0x0a, 0x60, 0x86, 0x48, 0x01, 0x86, 0xf8,
    0x4d, 0x01, 0x02, 0x01, 0x06, 0x0a, 0x60, 0x86, 0x48, 0x01, 0x86, 0xf8, 0x4d, 0x01, 0x02, 0x02,
    0x06, 0x0a, 0x60, 0x86, 0x48, 0x01, 0x86, 0xf8, 0x4d, 0x01, 0x02, 0x03, 0x30, 0x0b, 0x06, 0x03,
    0x55, 0x1d, 0x0f, 0x04, 0x04, 0x03, 0x02, 0x05, 0xe0, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48,
    0x86, 0xf7, 0x0d, 0x01, 0x01, 0x05, 0x05, 0x00, 0x03, 0x82, 0x01, 0x01, 0x00, 0x7d, 0x6e, 0xc4,
    0x07, 0xcd, 0x92, 0x62, 0xa0, 0xc8, 0x5a, 0xaf, 0x73, 0xa4, 0x7b, 0xde, 0xef, 0x57, 0xe7, 0x72,
    0x66, 0x11, 0x93, 0x2f, 0x48, 0x84, 0x75, 0xa6, 0x90, 0x67, 0x80, 0xfc, 0xa1, 0x02, 0xb3, 0x72,
    0x39, 0xf6, 0x44, 0xdb, 0x8b, 0x36, 0x8d, 0x67, 0xd4, 0xc6, 0x17, 0x21, 0x98, 0xbf, 0x1f, 0x5f,
    0xfa, 0x1e, 0x3d, 0x07, 0xaf, 0xd5, 0xa6, 0x30, 0xb2, 0x46, 0x15, 0xf7, 0x6c, 0x37, 0x44, 0x32,
    0x30, 0xde, 0xe6, 0xc5, 0x02, 0x9c, 0xc1, 0x16, 0xb4, 0xd9, 0x1c, 0x2e, 0xe3, 0xc0, 0xa7, 0x11,
    0x21, 0xe9, 0x48, 0xba, 0x9a, 0xc1, 0xdf, 0xa4, 0x04, 0xc3, 0x89, 0x03, 0xce, 0x14, 0x89, 0xf9,
    0x35, 0x91, 0x60, 0x7f, 0xc1, 0x7a, 0x55, 0x53, 0xc4, 0xbc, 0xe9, 0x87, 0x22, 0x64, 0xee, 0xa1,
    0xfc, 0x73, 0x2d, 0x17, 0x88, 0x6e, 0x5d, 0x08, 0x21, 0xcd, 0x0f, 0x3e, 0x6e, 0xf2, 0x34, 0xdc,
    0x5e, 0x60, 0x53, 0xc7, 0x27, 0x9f, 0x89, 0x1b, 0x84, 0x68, 0xc0, 0x12, 0xcc, 0x98, 0xdb, 0x28,
    0xc4, 0x7d, 0xb4, 0xcc, 0xd3, 0xb0, 0xa4, 0x18, 0xc2, 0xa5, 0xac, 0xf8, 0x57, 0x9e, 0xd9, 0x70,
    0xc7, 0xc8, 0x5f, 0x31, 0xd7, 0x5f, 0x2d, 0xb5, 0x21, 0xa9, 0x72, 0x56, 0xaa, 0xfd, 0x12, 0xd6,
    0x5a, 0x26, 0x66, 0xa7, 0x91, 0x0a, 0x12, 0xa5, 0xe4, 0x25, 0x75, 0xc6, 0x40, 0x7c, 0x15, 0xc4,
    0xfa, 0x0a, 0x9b, 0x0d, 0xd0, 0x37, 0x21, 0x3a, 0xe7, 0x18, 0x0d, 0x2e, 0x34, 0x30, 0xf8, 0xa4,
    0x22, 0x1e, 0x73, 0x00, 0xd7, 0xb9, 0x95, 0xcb, 0x30, 0x41, 0x5f, 0x2d, 0xe8, 0x41, 0xc3, 0xfd,
    0x92, 0x6e, 0x36, 0x53, 0x35, 0x0b, 0x9c, 0xd2, 0xb1, 0x89, 0x96, 0x00, 0xf7, 0x1a, 0x51, 0x86,
    0xa3, 0x8e, 0xbb, 0x70, 0x23, 0xb1, 0x3d, 0x4f, 0xa7, 0xc9, 0x74, 0x91, 0x03
};
/*len6 2 bytes*/
const ubyte4 dataLen_len6 = 2;
const sbyte data_len6[]    = {
    0x00, 0x04
};
/*serv_done 4 bytes*/
const ubyte4 dataLen_serv_done = 4;
const sbyte data_serv_done[]    = {
    0x0e, 0x00, 0x00, 0x00
};

MSTATUS write_ssl_fuzz(TCP_SOCKET socket, ubyte4 *pNumBytesWritten)
{
    MSTATUS status          = OK;
    ubyte4 numBytesWritten  = 0;

    (*pNumBytesWritten) = 0;

    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_type, dataLen_type, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_ver, dataLen_ver, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len1, dataLen_len1, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_htype1, dataLen_htype1, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len2, dataLen_len2, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_ver, dataLen_ver, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_rnd, dataLen_rnd, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len3, dataLen_len3, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_senID, dataLen_senID, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_cipher, dataLen_cipher, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_comp, dataLen_comp, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_type, dataLen_type, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_ver, dataLen_ver, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len4, dataLen_len4, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_htype2, dataLen_htype2, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len5, dataLen_len5, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len8, dataLen_len8, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_cert, dataLen_cert, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_type, dataLen_type, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_ver, dataLen_ver, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_len6, dataLen_len6, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;
    if (OK > (status = TCP_WRITE(socket, (sbyte*)data_serv_done, dataLen_serv_done, &numBytesWritten)))
        goto exit;
    (*pNumBytesWritten) += numBytesWritten;

exit:
    return status;

}

int main(void)
{
    sbyte         buffer[50];
    ubyte4        bytesRead        = 0;
    ubyte4        numBytesWritten  = 0;
    MSTATUS       status           = OK;
    TCP_SOCKET    listenSocket     = NULL;
    TCP_SOCKET    clientSocket     = NULL;

    mBreak = 0;

    if (OK > (status = TCP_INIT()))
        goto exit;

    if (OK > (status = TCP_LISTEN_SOCKET(&listenSocket, 1448)))
        goto exit;

    if (TRUE == mBreak)
        goto exit;

    while (!mBreak)
    {
        if (OK > (status = TCP_ACCEPT_SOCKET(&clientSocket, listenSocket, &mBreak)))
            goto exit;
        if (OK > (status = TCP_READ_AVL(clientSocket, (sbyte*)buffer, 50, &bytesRead, 0)))
        {
            if (ERR_TCP_READ_TIMEOUT == status)
                status = OK;
            if (OK > status)
                goto exit;
        }
        if (OK > (status = write_ssl_fuzz(clientSocket, &numBytesWritten)))
            goto exit;
        if (OK > (status = TCP_CLOSE_SOCKET(clientSocket)))
            goto exit;
        if (!__LOOP_SERVER__)
            mBreak = TRUE;
    }

exit:
    TCP_CLOSE_SOCKET(listenSocket);
    return status;
}
