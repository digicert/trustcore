/*
 * srp.c
 *
 * Secure Remote Protocol
 *
 * Copyright 2025 DigiCert Project Authors. All Rights Reserved.
 * 
 * DigiCert® TrustCore and TrustEdge are licensed under a dual-license model:
 * - **Open Source License**: GNU AGPL v3. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE
 * - **Commercial License**: Available under DigiCert’s Master Services Agreement. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE_COMMERCIAL.txt  
 *   or https://www.digicert.com/master-services-agreement/
 * 
 * *For commercial licensing, contact DigiCert at sales@digicert.com.*
 *
 */

#include "../common/moptions.h"
#include "../common/mtypes.h"
#include "../common/mocana.h"
#include "../crypto/hw_accel.h"

#include "../common/mdefs.h"
#include "../common/merrors.h"
#include "../common/mrtos.h"
#include "../common/mstdlib.h"
#include "../common/random.h"
#include "../common/vlong.h"
#include "../common/memory_debug.h"

#include "../crypto/sha1.h"
#include "../crypto/dh.h"
#include "../crypto/srp.h"
#ifdef __ENABLE_DIGICERT_CRYPTO_INTERFACE__
#include "../crypto_interface/crypto_interface_dh.h"
#endif

#if defined(__ENABLE_DIGICERT_SRP__) && !defined(__DISABLE_DIGICERT_DIFFIE_HELLMAN__)

#if __DIGICERT_MIN_SRP_BITS__ <= 1024

static const ubyte srp_1024[] =
{
    0xee, 0xaf, 0x0a, 0xb9, 0xad, 0xb3, 0x8d, 0xd6, 0x9c, 0x33, 0xf8, 0x0a,
    0xfa, 0x8f, 0xc5, 0xe8, 0x60, 0x72, 0x61, 0x87, 0x75, 0xff, 0x3c, 0x0b,
    0x9e, 0xa2, 0x31, 0x4c, 0x9c, 0x25, 0x65, 0x76, 0xd6, 0x74, 0xdf, 0x74,
    0x96, 0xea, 0x81, 0xd3, 0x38, 0x3b, 0x48, 0x13, 0xd6, 0x92, 0xc6, 0xe0,
    0xe0, 0xd5, 0xd8, 0xe2, 0x50, 0xb9, 0x8b, 0xe4, 0x8e, 0x49, 0x5c, 0x1d,
    0x60, 0x89, 0xda, 0xd1, 0x5d, 0xc7, 0xd7, 0xb4, 0x61, 0x54, 0xd6, 0xb6,
    0xce, 0x8e, 0xf4, 0xad, 0x69, 0xb1, 0x5d, 0x49, 0x82, 0x55, 0x9b, 0x29,
    0x7b, 0xcf, 0x18, 0x85, 0xc5, 0x29, 0xf5, 0x66, 0x66, 0x0e, 0x57, 0xec,
    0x68, 0xed, 0xbc, 0x3c, 0x05, 0x72, 0x6c, 0xc0, 0x2f, 0xd4, 0xcb, 0xf4,
    0x97, 0x6e, 0xaa, 0x9a, 0xfd, 0x51, 0x38, 0xfe, 0x83, 0x76, 0x43, 0x5b,
    0x9f, 0xc6, 0x1d, 0x2f, 0xc0, 0xeb, 0x06, 0xe3
};

static const ubyte srp_1024_k[SHA1_RESULT_SIZE] =
{
    0x75, 0x56, 0xaa, 0x04, 0x5a, 0xef, 0x2c, 0xdd,
    0x07, 0xab, 0xaf, 0x0f, 0x66, 0x5c, 0x3e, 0x81,
    0x89, 0x13, 0x18, 0x6f
};

#endif

#if __DIGICERT_MIN_SRP_BITS__ <= 1536

static const ubyte srp_1536[] =
{
    0x9d, 0xef, 0x3c, 0xaf, 0xb9, 0x39, 0x27, 0x7a, 0xb1, 0xf1, 0x2a, 0x86,
    0x17, 0xa4, 0x7b, 0xbb, 0xdb, 0xa5, 0x1d, 0xf4, 0x99, 0xac, 0x4c, 0x80,
    0xbe, 0xee, 0xa9, 0x61, 0x4b, 0x19, 0xcc, 0x4d, 0x5f, 0x4f, 0x5f, 0x55,
    0x6e, 0x27, 0xcb, 0xde, 0x51, 0xc6, 0xa9, 0x4b, 0xe4, 0x60, 0x7a, 0x29,
    0x15, 0x58, 0x90, 0x3b, 0xa0, 0xd0, 0xf8, 0x43, 0x80, 0xb6, 0x55, 0xbb,
    0x9a, 0x22, 0xe8, 0xdc, 0xdf, 0x02, 0x8a, 0x7c, 0xec, 0x67, 0xf0, 0xd0,
    0x81, 0x34, 0xb1, 0xc8, 0xb9, 0x79, 0x89, 0x14, 0x9b, 0x60, 0x9e, 0x0b,
    0xe3, 0xba, 0xb6, 0x3d, 0x47, 0x54, 0x83, 0x81, 0xdb, 0xc5, 0xb1, 0xfc,
    0x76, 0x4e, 0x3f, 0x4b, 0x53, 0xdd, 0x9d, 0xa1, 0x15, 0x8b, 0xfd, 0x3e,
    0x2b, 0x9c, 0x8c, 0xf5, 0x6e, 0xdf, 0x01, 0x95, 0x39, 0x34, 0x96, 0x27,
    0xdb, 0x2f, 0xd5, 0x3d, 0x24, 0xb7, 0xc4, 0x86, 0x65, 0x77, 0x2e, 0x43,
    0x7d, 0x6c, 0x7f, 0x8c, 0xe4, 0x42, 0x73, 0x4a, 0xf7, 0xcc, 0xb7, 0xae,
    0x83, 0x7c, 0x26, 0x4a, 0xe3, 0xa9, 0xbe, 0xb8, 0x7f, 0x8a, 0x2f, 0xe9,
    0xb8, 0xb5, 0x29, 0x2e, 0x5a, 0x02, 0x1f, 0xff, 0x5e, 0x91, 0x47, 0x9e,
    0x8c, 0xe7, 0xa2, 0x8c, 0x24, 0x42, 0xc6, 0xf3, 0x15, 0x18, 0x0f, 0x93,
    0x49, 0x9a, 0x23, 0x4d, 0xcf, 0x76, 0xe3, 0xfe, 0xd1, 0x35, 0xf9, 0xbb
};

static const ubyte srp_1536_k[SHA1_RESULT_SIZE] =
{
    0x81, 0x5a, 0x45, 0x61, 0xe1, 0xa6, 0x8b, 0x3f,
    0xb7, 0xf6, 0xc0, 0x3b, 0xbb, 0x3d, 0xaa, 0xa3,
    0x5d, 0x52, 0x8d, 0x90,

};

#endif

#if __DIGICERT_MIN_SRP_BITS__ <= 2048

static const ubyte srp_2048[] =
{
    0xac, 0x6b, 0xdb, 0x41, 0x32, 0x4a, 0x9a, 0x9b, 0xf1, 0x66, 0xde, 0x5e,
    0x13, 0x89, 0x58, 0x2f, 0xaf, 0x72, 0xb6, 0x65, 0x19, 0x87, 0xee, 0x07,
    0xfc, 0x31, 0x92, 0x94, 0x3d, 0xb5, 0x60, 0x50, 0xa3, 0x73, 0x29, 0xcb,
    0xb4, 0xa0, 0x99, 0xed, 0x81, 0x93, 0xe0, 0x75, 0x77, 0x67, 0xa1, 0x3d,
    0xd5, 0x23, 0x12, 0xab, 0x4b, 0x03, 0x31, 0x0d, 0xcd, 0x7f, 0x48, 0xa9,
    0xda, 0x04, 0xfd, 0x50, 0xe8, 0x08, 0x39, 0x69, 0xed, 0xb7, 0x67, 0xb0,
    0xcf, 0x60, 0x95, 0x17, 0x9a, 0x16, 0x3a, 0xb3, 0x66, 0x1a, 0x05, 0xfb,
    0xd5, 0xfa, 0xaa, 0xe8, 0x29, 0x18, 0xa9, 0x96, 0x2f, 0x0b, 0x93, 0xb8,
    0x55, 0xf9, 0x79, 0x93, 0xec, 0x97, 0x5e, 0xea, 0xa8, 0x0d, 0x74, 0x0a,
    0xdb, 0xf4, 0xff, 0x74, 0x73, 0x59, 0xd0, 0x41, 0xd5, 0xc3, 0x3e, 0xa7,
    0x1d, 0x28, 0x1e, 0x44, 0x6b, 0x14, 0x77, 0x3b, 0xca, 0x97, 0xb4, 0x3a,
    0x23, 0xfb, 0x80, 0x16, 0x76, 0xbd, 0x20, 0x7a, 0x43, 0x6c, 0x64, 0x81,
    0xf1, 0xd2, 0xb9, 0x07, 0x87, 0x17, 0x46, 0x1a, 0x5b, 0x9d, 0x32, 0xe6,
    0x88, 0xf8, 0x77, 0x48, 0x54, 0x45, 0x23, 0xb5, 0x24, 0xb0, 0xd5, 0x7d,
    0x5e, 0xa7, 0x7a, 0x27, 0x75, 0xd2, 0xec, 0xfa, 0x03, 0x2c, 0xfb, 0xdb,
    0xf5, 0x2f, 0xb3, 0x78, 0x61, 0x60, 0x27, 0x90, 0x04, 0xe5, 0x7a, 0xe6,
    0xaf, 0x87, 0x4e, 0x73, 0x03, 0xce, 0x53, 0x29, 0x9c, 0xcc, 0x04, 0x1c,
    0x7b, 0xc3, 0x08, 0xd8, 0x2a, 0x56, 0x98, 0xf3, 0xa8, 0xd0, 0xc3, 0x82,
    0x71, 0xae, 0x35, 0xf8, 0xe9, 0xdb, 0xfb, 0xb6, 0x94, 0xb5, 0xc8, 0x03,
    0xd8, 0x9f, 0x7a, 0xe4, 0x35, 0xde, 0x23, 0x6d, 0x52, 0x5f, 0x54, 0x75,
    0x9b, 0x65, 0xe3, 0x72, 0xfc, 0xd6, 0x8e, 0xf2, 0x0f, 0xa7, 0x11, 0x1f,
    0x9e, 0x4a, 0xff, 0x73
};

static const ubyte srp_2048_k[SHA1_RESULT_SIZE] =
{
    0xa5, 0x63, 0x03, 0xf3, 0x2c, 0x60, 0xe5, 0x99,
    0xe8, 0x2c, 0x39, 0x6f, 0x0d, 0x57, 0xf1, 0xb3,
    0x44, 0xa7, 0x31, 0x3c,
};

#endif

static const ubyte srp_3072_k[SHA1_RESULT_SIZE] =
{
    0xc2, 0xfd, 0x8f, 0x8b, 0x27, 0x4f, 0xa6, 0x34,
    0xef, 0xd7, 0x02, 0xbd, 0x22, 0xfb, 0x6c, 0x12,
    0x18, 0xd9, 0xf2, 0xa0
};

static const ubyte srp_4096_k[SHA1_RESULT_SIZE] =
{
    0xa5, 0x21, 0x69, 0x46, 0x05, 0x81, 0x0c, 0x01,
    0xab, 0xdf, 0xa0, 0x1f, 0xd6, 0x20, 0x71, 0x73,
    0xa5, 0x61, 0x78, 0xe9
};

static const ubyte srp_6144_k[SHA1_RESULT_SIZE] =
{
    0x15, 0x3c, 0x65, 0xe6, 0x05, 0x8e, 0xbc, 0xab,
    0x71, 0x4d, 0x69, 0x40, 0x81, 0x80, 0x15, 0xc2,
    0x28, 0x3a, 0xdc, 0xb2
};

static const ubyte srp_8192_k[SHA1_RESULT_SIZE] =
{
    0x3b, 0xc2, 0x48, 0xed, 0xfa, 0xfe, 0xf1, 0x5a,
    0x15, 0x51, 0x83, 0x51, 0xb4, 0x3d, 0xfc, 0xa0,
    0xa3, 0x7c, 0x49, 0x41
};


/*--------------------------------------------------------------------------*/

extern MSTATUS
SRP_getGroupParameters( ubyte4 bitNum, vlong** modulus, vlong** generator,
                       vlong** srpk)
{
    MSTATUS status = OK;
    const ubyte* modulusBytes;
    const ubyte* generatorBytes;
    const ubyte* kBytes;
    sbyte4 modulusLen, genLen;
    vlong* n = 0;
    vlong* g = 0;
    vlong* k = 0;

    if (OK > ( status = SRP_getGroupParameters2(bitNum,
                                                &modulusBytes, &modulusLen,
                                                &generatorBytes, &genLen,
                                                &kBytes)))
    {
        goto exit;
    }

    if (OK > (status = VLONG_vlongFromByteString(modulusBytes, modulusLen,
                                                 &n, 0)))
    {
        goto exit;
    }

    if (OK > (status = VLONG_vlongFromByteString(generatorBytes, genLen,
                                                 &g, 0)))
    {
        goto exit;
    }

    if (OK > (status = VLONG_vlongFromByteString(kBytes, SHA1_RESULT_SIZE,
                                                 &k, 0)))
    {
        goto exit;
    }

    *modulus = n; n = 0;
    *generator = g; g = 0;
    *srpk = k; k = 0;
exit:

    VLONG_freeVlong(&k, 0);
    VLONG_freeVlong(&g, 0);
    VLONG_freeVlong(&n, 0);
    return status;
}



/*--------------------------------------------------------------------------*/

extern MSTATUS
SRP_getGroupParameters2( ubyte4 bitNum, const ubyte** modulus, sbyte4* modulusLen,
                        const ubyte** generator, sbyte4* generatorLen,
                        const ubyte** k)
{
    MSTATUS status = OK;
    static const ubyte kGenerators[] =
    {
        2, 5, 19
    };


    if (bitNum < __DIGICERT_MIN_SRP_BITS__)
    {
        status = ERR_INVALID_ARG;
        goto exit;
    }

    switch(bitNum)
    {
#if __DIGICERT_MIN_SRP_BITS__ <= 1024
        case 1024: /* 2 */
            *k = srp_1024_k;
            *generator = kGenerators;
            *modulus = srp_1024;
            *modulusLen = sizeof(srp_1024);
            break;
#endif

#if __DIGICERT_MIN_SRP_BITS__ <= 1536
        case 1536: /* 2 */
            *k = srp_1536_k;
            *generator = kGenerators;
            *modulus = srp_1536;
            *modulusLen = sizeof(srp_1536);
            break;
#endif

#if __DIGICERT_MIN_SRP_BITS__ <= 2048
        case 2048: /* 2 */
            *k = srp_2048_k;
            *generator = kGenerators;
            *modulus = srp_2048;
            *modulusLen = sizeof(srp_2048);
            break;
#endif

        case 3072: /* 5 */
            *k = srp_3072_k;
            *generator = kGenerators+1;
#ifdef __ENABLE_DIGICERT_CRYPTO_INTERFACE__
            CRYPTO_INTERFACE_DH_getPByteString( DH_GROUP_15, modulus, modulusLen);
#else
            DH_getPByteString( DH_GROUP_15, modulus, modulusLen);
#endif
            break;

        case 4096: /* 5 */
            *k = srp_4096_k;
           *generator = kGenerators+1;
#ifdef __ENABLE_DIGICERT_CRYPTO_INTERFACE__
            CRYPTO_INTERFACE_DH_getPByteString(DH_GROUP_16, modulus, modulusLen);
#else
            DH_getPByteString(DH_GROUP_16, modulus, modulusLen);
#endif
            break;

        case 6144: /* 5 */
            *k = srp_6144_k;
            *generator = kGenerators+1;
#ifdef __ENABLE_DIGICERT_CRYPTO_INTERFACE__
            CRYPTO_INTERFACE_DH_getPByteString(DH_GROUP_17, modulus, modulusLen);
#else
            DH_getPByteString(DH_GROUP_17, modulus, modulusLen);
#endif
            break;

        case 8192: /* 19 */
            *k = srp_8192_k;
            *generator = kGenerators+2;
#ifdef __ENABLE_DIGICERT_CRYPTO_INTERFACE__
            CRYPTO_INTERFACE_DH_getPByteString(DH_GROUP_18, modulus, modulusLen);
#else
            DH_getPByteString(DH_GROUP_18, modulus, modulusLen);
#endif
            break;

        default:
            status = ERR_INVALID_ARG;
            goto exit;
    }

    *generatorLen = 1;

exit:

    return status;

}


/*--------------------------------------------------------------------------*/

extern MSTATUS
SRP_computeVerifier(MOC_ASYM(hwAccelDescr hwAccelCtx)
                    const ubyte* salt, ubyte4 saltLen,
                    const ubyte* uname, ubyte4 unameLen,
                    const ubyte* pw, ubyte4 pwLen,
                    ubyte4 bitNum,
                    ubyte** verifier, ubyte4* verifierLen)
{
    MSTATUS status;
    SHA1_CTX ctx = {0};
    ubyte x[SHA1_RESULT_SIZE];
    vlong* groupModulus = 0;
    vlong* groupGenerator = 0;
    vlong* groupK = 0;
    vlong* v = 0;
    vlong* pVlongQueue = 0;
    vlong* e = 0;
    ubyte* verif = 0;

    if (!salt || !uname || !pw || !verifier || !verifierLen)
    {
        return ERR_NULL_POINTER;
    }

    /* x = SHA1( salt | SHA1( uname | ':' | pw)) */
    SHA1_initDigest(MOC_HASH(hwAccelCtx) &ctx);
    SHA1_updateDigest(MOC_HASH(hwAccelCtx) &ctx, uname, unameLen);
    x[0] = (ubyte)':';
    SHA1_updateDigest(MOC_HASH(hwAccelCtx) &ctx, x, 1);
    SHA1_updateDigest(MOC_HASH(hwAccelCtx) &ctx, pw, pwLen);
    SHA1_finalDigest(MOC_HASH(hwAccelCtx) &ctx, x);
    SHA1_initDigest(MOC_HASH(hwAccelCtx) &ctx);
    SHA1_updateDigest(MOC_HASH(hwAccelCtx) &ctx, salt, saltLen);
    SHA1_updateDigest(MOC_HASH(hwAccelCtx) &ctx, x, SHA1_RESULT_SIZE);
    SHA1_finalDigest(MOC_HASH(hwAccelCtx) &ctx, x);

    if (OK > ( status = VLONG_vlongFromByteString(x, SHA1_RESULT_SIZE,
                                                  &e, 0)))
    {
        goto exit;
    }

    if (OK > (status = SRP_getGroupParameters(bitNum,
                                              &groupModulus, &groupGenerator,
                                              &groupK)))
    {
        goto exit;
    }

    if (OK > (status = VLONG_modexp(MOC_MOD(hwAccelCtx)
                                    groupGenerator, e, groupModulus,
                                    &v, &pVlongQueue)))
    {
        goto exit;
    }

    if (OK > ( status = VLONG_byteStringFromVlong(v, 0, (sbyte4*) verifierLen)))
    {
        goto exit;
    }

    verif = (ubyte*) MALLOC(*verifierLen);
    if (!verif)
    {
        status = ERR_MEM_ALLOC_FAIL;
        goto exit;
    }

    if (OK > ( status = VLONG_byteStringFromVlong(v, verif, (sbyte4*) verifierLen)))
    {
        goto exit;
    }

    *verifier = verif;
    verif = 0;

exit:

    VLONG_freeVlong(&e, 0);
    VLONG_freeVlong(&groupK, 0);
    VLONG_freeVlong(&groupModulus, 0);
    VLONG_freeVlong(&groupGenerator, 0);
    VLONG_freeVlong(&v, 0);

    FREE(verif);

    VLONG_freeVlongQueue(&pVlongQueue);
    return status;

}

#endif
