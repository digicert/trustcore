/*
 * moccms_test.c
 *
 * Unit tests for CMS - moccms.c
 *
 * Copyright 2025 DigiCert Project Authors. All Rights Reserved.
 * 
 * DigiCert® TrustCore and TrustEdge are licensed under a dual-license model:
 * - **Open Source License**: GNU AGPL v3. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE
 * - **Commercial License**: Available under DigiCert’s Master Services Agreement. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE_COMMERCIAL.txt  
 *   or https://www.digicert.com/master-services-agreement/
 * 
 * *For commercial licensing, contact DigiCert at sales@digicert.com.*
 *
 */
#include "../../asn1/mocasn1.h"
#include "../../asn1/oiddefs.h"

#include "../../../unit_tests/unittest.h"

#include "../../common/utils.h"
#include "../../common/memfile.h"
#include "../../common/absstream.h"
#include "../../common/mrtos.h"

#include "../../crypto/aes.h"
#include "../../crypto/pubcrypto.h"
#include "../../crypto/ca_mgmt.h"
#include "../../crypto/pkcs_common.h"
#include "../../crypto/pkcs_key.h"
#include "../../crypto/pkcs7.h"
#include "../../crypto/cms.h"
#include "../../crypto/des.h"
#include "../../crypto/moccms.h"
#include "../../crypto/moccms_util.h"
#include "../../crypto/mocasym.h"

#include "../../harness/harness.h"

#include <stdio.h>

/* File under test */
#include "../../crypto/moccms.c"

/*********************************************************************************/

typedef struct
{
   ubyte* buf;
   ubyte4 bufUsed;
   ubyte4 bufMax;
   intBoolean done;
} internal_test;

typedef struct CertificateInfo
{
   const char* certFileName;
   const char* certKeyFileName;
} CertificateInfo;

/*********************************************************************************/

static CertificateInfo gCertificateInfos[] =
      {
            { "signer1cert.der", "signer1cert_key.dat" },
            { "signer2cert.der", "signer2cert_key.dat" },
            { "recipient1.der", "recipient1.key" },
            { "recipient2.der", "recipient2.key" },
            { "ecc_selfcert.der", "ecc_keyblobFile.dat" },
            { "dsa2048.crt.der", "dsa2048.crt.key" },
            { "rsa4096.crt.der", "rsa4096.key.dat" } ,
            { "cms_test_crt.der", "cms_test_key.der" } ,
            { "signer_rsa_crt.der", "signer_rsa_key.der" } ,
      };


/***************************************************************************************/

static MSTATUS
internal_CMS_checkCertificateIssuerSerialNumber(
        ubyte* pIssuer,
        ubyte4 issuerLen,
        ubyte* pSerialNumber,
        ubyte4 serialNumberLen,
        ubyte *pCert,
        ubyte4 certLen);

/***************************************************************************************/

static MSTATUS
internal_CMS_checkCertificateIssuerSerialNumber(
        ubyte* pIssuer,
        ubyte4 issuerLen,
        ubyte* pSerialNumber,
        ubyte4 serialNumberLen,
        ubyte* pCert,
        ubyte4 certLen)
{
    MSTATUS status;
    ubyte *pData;
    ubyte4 dataLen;

    status = DIGI_CMS_U_parseX509CertForSerialNumber (pCert, certLen,
                                                     &pData, &dataLen);
    if (OK != status)
        goto exit;

    if (dataLen != serialNumberLen)
    {
       status = ERR_FALSE;
    }
    else
    {
       sbyte4 cmpResult;
       status = DIGI_MEMCMP (pData, pSerialNumber, dataLen, &cmpResult);
       if (OK != status)
           goto exit;
       if (0 != cmpResult)
       {
          status = ERR_FALSE;
       }
    }

    /* Already failed? */
    if (OK != status)
        goto exit;

    status = DIGI_CMS_U_parseX509CertForIssuerName (pCert, certLen,
                                                   &pData, &dataLen);
    if (OK != status)
        goto exit;

    if (dataLen != issuerLen)
    {
       status = ERR_FALSE;
    }
    else
    {
       sbyte4 cmpResult;
       status = DIGI_MEMCMP (pData, pIssuer, dataLen, &cmpResult);
       if (OK != status)
           goto exit;
       if (0 != cmpResult)
       {
          status = ERR_FALSE;
       }
    }

exit:
    return status;
}

/*----------------------------------------------------------------------*/

static MSTATUS
dummyCertificateCB(const void* arg,
                   ubyte* pSerialNumber,
                   ubyte4 serialNumberLen,
                   ubyte* pIssuer,
                   ubyte4 issuerLen,
                   ubyte** ppCertificate,
                   ubyte4* pCertificateLen)
{
    MSTATUS status = ERR_FALSE;
    ubyte* pCert = NULL;
    ubyte4 certLen;
    intBoolean match = FALSE;
    ubyte4 i;

    for ( i = 0; i < COUNTOF (gCertificateInfos); ++i)
    {
        status = DIGICERT_readFile(gCertificateInfos[i].certFileName, &pCert, &certLen);
        if (OK != status)
            continue;

        status = internal_CMS_checkCertificateIssuerSerialNumber (pIssuer,
                                                                  issuerLen,
                                                                  pSerialNumber,
                                                                  serialNumberLen,
                                                                  pCert, certLen);

        /* Check the signer's certificate matches the Issuer name and Serial Number.
         * If yes, return the signer's certificate, otherwise continue looping for
         * the signer's certificate. */
        if (OK == status)
        {
            match = TRUE;
            break;
        }

        FREE (pCert);
        pCert = NULL;
    }

    if (TRUE == match)
    {
        *ppCertificate = pCert;
        *pCertificateLen = certLen;
        pCert = NULL;
    }

    if (NULL !=pCert)
    {
        FREE(pCert);
        pCert = NULL;
    }
    return status;
}


/*----------------------------------------------------------------------*/

static MSTATUS
dummyVerifyCert(const void* arg,
                ubyte* pCertificate,
                ubyte4 certificateLen,
                MOC_CMS_MsgSignInfo *pSigInfo)
{
    MSTATUS status = OK;

    return status;
}


/*----------------------------------------------------------------------*/

static MSTATUS
internal_verifyCallback(const void* arg,
                        MOC_CMS_context pCtx,
                        MOC_CMS_UpdateType type,
                        ubyte* pBuf,
                        ubyte4 bufLen)
{
    internal_test* t = (internal_test*)arg;

    if (E_MOC_CMS_ut_result == type)
    {
        t->done = TRUE;
    }
    else if (NULL != pBuf)
    {
        if (t->bufMax > (t->bufUsed + bufLen))
        {
            DIGI_MEMCPY(t->buf + t->bufUsed, pBuf, bufLen);
            t->bufUsed += bufLen;
        }
        else
        {
            return ERR_FALSE;
        }
    }

    return OK;
}


int
moccms_test_testInDataCerts()
{
    MSTATUS status = OK;
    int retval = 0;

    ubyte       *pCMS = NULL;
    ubyte4      cmsLen;
    const ubyte *pCERTS = NULL;
    ubyte4      CERTLen;
    sbyte4      cmpResult = -1;

    intBoolean          finished = FALSE;
    internal_test*      t = NULL;
    MOC_CMS_context     ctx = NULL;
    MOC_CMS_Callbacks   cb = { 0 };
    MOC_CMS_ContentType content_type;

    ubyte signer_rsa_crt_der[] = {
      0x30, 0x82, 0x05, 0x7f, 0x30, 0x82, 0x03, 0x67, 0xa0, 0x03, 0x02, 0x01,
      0x02, 0x02, 0x09, 0x00, 0x8d, 0x52, 0xcd, 0x3a, 0xad, 0x69, 0x44, 0x10,
      0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01,
      0x0b, 0x05, 0x00, 0x30, 0x56, 0x31, 0x0b, 0x30, 0x09, 0x06, 0x03, 0x55,
      0x04, 0x06, 0x13, 0x02, 0x55, 0x53, 0x31, 0x10, 0x30, 0x0e, 0x06, 0x03,
      0x55, 0x04, 0x08, 0x0c, 0x07, 0x46, 0x6c, 0x6f, 0x72, 0x69, 0x64, 0x61,
      0x31, 0x11, 0x30, 0x0f, 0x06, 0x03, 0x55, 0x04, 0x07, 0x0c, 0x08, 0x4c,
      0x61, 0x6b, 0x65, 0x6c, 0x61, 0x6e, 0x64, 0x31, 0x0f, 0x30, 0x0d, 0x06,
      0x03, 0x55, 0x04, 0x0a, 0x0c, 0x06, 0x4d, 0x6f, 0x63, 0x61, 0x6e, 0x61,
      0x31, 0x11, 0x30, 0x0f, 0x06, 0x03, 0x55, 0x04, 0x0b, 0x0c, 0x08, 0x52,
      0x53, 0x41, 0x2d, 0x34, 0x30, 0x39, 0x36, 0x30, 0x1e, 0x17, 0x0d, 0x31,
      0x38, 0x30, 0x31, 0x32, 0x39, 0x31, 0x35, 0x31, 0x36, 0x30, 0x38, 0x5a,
      0x17, 0x0d, 0x32, 0x38, 0x30, 0x31, 0x32, 0x37, 0x31, 0x35, 0x31, 0x36,
      0x30, 0x38, 0x5a, 0x30, 0x56, 0x31, 0x0b, 0x30, 0x09, 0x06, 0x03, 0x55,
      0x04, 0x06, 0x13, 0x02, 0x55, 0x53, 0x31, 0x10, 0x30, 0x0e, 0x06, 0x03,
      0x55, 0x04, 0x08, 0x0c, 0x07, 0x46, 0x6c, 0x6f, 0x72, 0x69, 0x64, 0x61,
      0x31, 0x11, 0x30, 0x0f, 0x06, 0x03, 0x55, 0x04, 0x07, 0x0c, 0x08, 0x4c,
      0x61, 0x6b, 0x65, 0x6c, 0x61, 0x6e, 0x64, 0x31, 0x0f, 0x30, 0x0d, 0x06,
      0x03, 0x55, 0x04, 0x0a, 0x0c, 0x06, 0x4d, 0x6f, 0x63, 0x61, 0x6e, 0x61,
      0x31, 0x11, 0x30, 0x0f, 0x06, 0x03, 0x55, 0x04, 0x0b, 0x0c, 0x08, 0x52,
      0x53, 0x41, 0x2d, 0x34, 0x30, 0x39, 0x36, 0x30, 0x82, 0x02, 0x22, 0x30,
      0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x01,
      0x05, 0x00, 0x03, 0x82, 0x02, 0x0f, 0x00, 0x30, 0x82, 0x02, 0x0a, 0x02,
      0x82, 0x02, 0x01, 0x00, 0xbc, 0x6f, 0x96, 0x11, 0x49, 0x79, 0x6b, 0xbb,
      0xc9, 0x59, 0x48, 0xc5, 0xaa, 0x19, 0x58, 0xb9, 0xce, 0x06, 0xc3, 0xaa,
      0x43, 0x9e, 0xa0, 0xc4, 0xb7, 0x6d, 0x84, 0x55, 0x5b, 0xe7, 0x01, 0x38,
      0x54, 0x28, 0x75, 0x80, 0x20, 0x85, 0x8b, 0x71, 0xfa, 0x49, 0x5b, 0x8a,
      0x55, 0x74, 0x91, 0x63, 0xab, 0xb1, 0x4d, 0xae, 0xae, 0x35, 0xe5, 0x29,
      0x86, 0xb1, 0x7e, 0x32, 0xa7, 0x8d, 0x8d, 0x6f, 0xaa, 0xe8, 0x20, 0x5b,
      0xaa, 0x63, 0xa1, 0xc9, 0xef, 0x7c, 0x02, 0x7d, 0xaa, 0x80, 0x2a, 0xb3,
      0x0a, 0xaa, 0x28, 0x36, 0xfa, 0x86, 0xfb, 0x79, 0x6e, 0xc9, 0xa7, 0x9f,
      0xdb, 0x13, 0x23, 0x15, 0x05, 0x89, 0x45, 0x62, 0x04, 0x65, 0x05, 0x10,
      0x66, 0x5c, 0x83, 0xe9, 0xed, 0x43, 0xed, 0x2b, 0xe8, 0xf8, 0x4a, 0xb0,
      0xd3, 0xb6, 0xec, 0x0e, 0xb1, 0xd3, 0xdb, 0x06, 0x24, 0xc8, 0xa6, 0xed,
      0x5a, 0xaa, 0xb2, 0x6d, 0xc6, 0x5a, 0x45, 0x70, 0x12, 0xd5, 0x16, 0xbc,
      0xff, 0xad, 0xd6, 0x0e, 0x49, 0x18, 0xae, 0xa9, 0x99, 0xf7, 0xb9, 0x19,
      0x1f, 0xe4, 0x05, 0x15, 0x62, 0x0f, 0xe1, 0xe4, 0x3d, 0x98, 0x46, 0x29,
      0x4a, 0xf1, 0x76, 0x7d, 0x49, 0xb9, 0xfe, 0x09, 0xce, 0xb6, 0xa2, 0x13,
      0xe8, 0x4c, 0x53, 0x4e, 0xf0, 0x9c, 0xec, 0x8a, 0xe2, 0x86, 0x72, 0xf4,
      0x1c, 0x9d, 0x50, 0xac, 0x50, 0x9f, 0xbd, 0x9d, 0xc8, 0xd1, 0x09, 0xb5,
      0xd7, 0x43, 0x4e, 0x5d, 0xda, 0x3c, 0x0a, 0x6f, 0x63, 0xfd, 0xa2, 0x54,
      0x6e, 0x34, 0xb8, 0xcc, 0xbc, 0x96, 0x10, 0x3a, 0x5f, 0x23, 0xb4, 0x67,
      0x69, 0x12, 0x7e, 0x9e, 0x28, 0x17, 0x23, 0xe4, 0x81, 0x3b, 0x98, 0x66,
      0xa0, 0x97, 0xab, 0xf4, 0x6f, 0x18, 0x85, 0x6e, 0xf1, 0x21, 0x9f, 0xe8,
      0x2b, 0x62, 0x26, 0x22, 0x2c, 0x23, 0xb1, 0xa2, 0xa1, 0x68, 0xcb, 0xdd,
      0x20, 0x9c, 0xcd, 0x5a, 0xbc, 0xef, 0x20, 0x0b, 0x12, 0xcd, 0x54, 0x73,
      0x0f, 0x7d, 0xeb, 0x48, 0xe7, 0x4c, 0x83, 0x97, 0xb9, 0xd2, 0xa7, 0x9f,
      0xc6, 0x52, 0xa1, 0x43, 0x9e, 0x19, 0x05, 0x95, 0x17, 0xb2, 0xbd, 0x7a,
      0xb2, 0x27, 0xac, 0xac, 0x50, 0x3e, 0x51, 0xd5, 0x34, 0x4f, 0x5a, 0x35,
      0x83, 0x19, 0x10, 0x92, 0x21, 0x10, 0xab, 0x55, 0x97, 0xfc, 0x1c, 0x52,
      0xaf, 0x2a, 0x1e, 0x11, 0x62, 0x1f, 0xb9, 0xe9, 0xea, 0x9f, 0x0f, 0x29,
      0x6c, 0xd9, 0x6a, 0xaa, 0xb8, 0x7a, 0xc5, 0xd1, 0x4e, 0xc0, 0xf8, 0x1c,
      0xd8, 0x77, 0x43, 0xb4, 0xfa, 0x8d, 0x69, 0x75, 0xb2, 0x9c, 0xa6, 0x50,
      0x2f, 0xa6, 0x90, 0x36, 0x70, 0xcc, 0xe6, 0x67, 0x59, 0xc1, 0xf7, 0x9b,
      0x0b, 0x0f, 0x90, 0xfe, 0x6a, 0x4b, 0x6c, 0x6c, 0xb7, 0x4e, 0xe1, 0x13,
      0x08, 0x98, 0x74, 0xe6, 0x08, 0xb5, 0x35, 0x28, 0xee, 0x0f, 0x70, 0x7f,
      0xe7, 0x01, 0x13, 0xc8, 0x5f, 0x9b, 0x21, 0x89, 0xad, 0xbe, 0xd8, 0xbd,
      0x9e, 0x3f, 0x71, 0x88, 0x4e, 0xa8, 0x93, 0xe5, 0x43, 0xa1, 0x65, 0xef,
      0x54, 0x62, 0x1b, 0x56, 0x8a, 0x1e, 0x93, 0x5e, 0x7e, 0xde, 0xf2, 0xd3,
      0xc1, 0x9e, 0xe3, 0x52, 0x5b, 0x21, 0xca, 0x3e, 0x37, 0xd6, 0x1c, 0x5a,
      0x8a, 0x86, 0x43, 0xb2, 0x24, 0x65, 0x15, 0x58, 0xc3, 0xcc, 0xd6, 0x8a,
      0x56, 0x5c, 0x4c, 0x27, 0xe2, 0x35, 0xfc, 0x63, 0x67, 0xd7, 0x8b, 0x1d,
      0x02, 0x71, 0xe5, 0xa3, 0x20, 0xf7, 0xe4, 0xad, 0xd6, 0x53, 0xfc, 0x8d,
      0x84, 0xa4, 0x53, 0xbb, 0x5b, 0xa5, 0x5f, 0x00, 0xaa, 0xc8, 0x0d, 0xdc,
      0x38, 0xd2, 0x78, 0x18, 0xa7, 0xe2, 0x25, 0xd5, 0xac, 0x87, 0x28, 0xf1,
      0x69, 0x6b, 0xae, 0x07, 0xc0, 0xa0, 0x61, 0x34, 0x89, 0x49, 0x59, 0xcd,
      0x02, 0x03, 0x01, 0x00, 0x01, 0xa3, 0x50, 0x30, 0x4e, 0x30, 0x1d, 0x06,
      0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0x23, 0xf6, 0xea, 0x1b,
      0x1b, 0x30, 0x73, 0xd3, 0x1b, 0x4d, 0x90, 0x21, 0x2d, 0x17, 0xda, 0xbf,
      0xab, 0x3d, 0x97, 0xfb, 0x30, 0x1f, 0x06, 0x03, 0x55, 0x1d, 0x23, 0x04,
      0x18, 0x30, 0x16, 0x80, 0x14, 0x23, 0xf6, 0xea, 0x1b, 0x1b, 0x30, 0x73,
      0xd3, 0x1b, 0x4d, 0x90, 0x21, 0x2d, 0x17, 0xda, 0xbf, 0xab, 0x3d, 0x97,
      0xfb, 0x30, 0x0c, 0x06, 0x03, 0x55, 0x1d, 0x13, 0x04, 0x05, 0x30, 0x03,
      0x01, 0x01, 0xff, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7,
      0x0d, 0x01, 0x01, 0x0b, 0x05, 0x00, 0x03, 0x82, 0x02, 0x01, 0x00, 0x22,
      0xb8, 0xf4, 0xf8, 0x91, 0x8e, 0x0c, 0x14, 0x14, 0x5b, 0x0f, 0x61, 0x43,
      0x25, 0xba, 0x0f, 0xf4, 0x28, 0x4e, 0xc8, 0x60, 0xd6, 0xe4, 0x4c, 0x64,
      0xa5, 0x64, 0x2b, 0x0e, 0xd3, 0x87, 0xbd, 0xd6, 0x6a, 0x15, 0x03, 0xf2,
      0xdc, 0x0b, 0xf9, 0xb9, 0x7c, 0x58, 0x59, 0x13, 0xe8, 0x66, 0xde, 0x87,
      0xe8, 0x02, 0xa8, 0xfe, 0x3b, 0x13, 0x5c, 0x25, 0x74, 0xb5, 0x74, 0x37,
      0x3d, 0x20, 0x69, 0xdb, 0xdd, 0x9d, 0x9f, 0x53, 0x1e, 0xeb, 0xc2, 0xe2,
      0xaa, 0xcb, 0x93, 0x2c, 0x47, 0x9a, 0xf3, 0xf3, 0x86, 0xfd, 0xf2, 0xed,
      0x0b, 0xba, 0x9e, 0x20, 0x6c, 0x05, 0x42, 0x55, 0xd2, 0x14, 0xdd, 0xc5,
      0x4b, 0x1e, 0x4b, 0x5c, 0xe1, 0xe4, 0x4f, 0xd8, 0x5a, 0x1c, 0xb8, 0xfc,
      0x62, 0xa5, 0xd3, 0x11, 0xaa, 0x4b, 0x6b, 0xe0, 0xd8, 0x30, 0x94, 0xc3,
      0x0b, 0x66, 0xa6, 0x82, 0xe3, 0x66, 0x48, 0xba, 0x77, 0x9f, 0x85, 0x9e,
      0xfb, 0x6d, 0x92, 0x25, 0x3f, 0x3b, 0xf5, 0x56, 0x9f, 0xa9, 0x24, 0x5d,
      0x40, 0x10, 0xc5, 0x55, 0x8b, 0xd2, 0xef, 0x08, 0x75, 0xbd, 0xcb, 0xd9,
      0x6f, 0xa1, 0x09, 0x52, 0x82, 0x43, 0xb9, 0x39, 0x23, 0xbe, 0xc0, 0xd0,
      0xdc, 0xf5, 0x91, 0xd8, 0xff, 0x2c, 0x39, 0x21, 0x49, 0x9c, 0xd4, 0x92,
      0x38, 0x53, 0x89, 0x32, 0xa8, 0xf4, 0x1d, 0xb5, 0x3a, 0x0e, 0x58, 0xe2,
      0x33, 0x9d, 0x27, 0xc8, 0x64, 0x53, 0x54, 0xd6, 0xe7, 0x9d, 0x29, 0x37,
      0x8d, 0xba, 0x8d, 0x84, 0xa3, 0x43, 0x37, 0x3d, 0x5e, 0x78, 0x0c, 0xa1,
      0x75, 0x91, 0x76, 0x62, 0x75, 0xe2, 0xf4, 0xe1, 0x2d, 0xca, 0xd2, 0x9b,
      0x92, 0x64, 0xdd, 0x9d, 0x5f, 0xec, 0x23, 0x7a, 0x80, 0xb2, 0x39, 0xd9,
      0x32, 0xfc, 0xd5, 0xe2, 0x73, 0x3d, 0xd0, 0xd3, 0x5b, 0x7a, 0x32, 0xcc,
      0xc6, 0xe1, 0xea, 0x44, 0xaa, 0xc3, 0x0a, 0xd1, 0x34, 0x3a, 0x2c, 0xba,
      0x61, 0x90, 0xff, 0x83, 0xf0, 0x0b, 0x27, 0x69, 0x24, 0x18, 0x9b, 0x9d,
      0xd3, 0xa0, 0x29, 0x39, 0x94, 0xd1, 0xaf, 0xad, 0x13, 0xe4, 0x08, 0xb4,
      0x4a, 0x44, 0xdf, 0xc9, 0xca, 0x19, 0x7a, 0xd5, 0x45, 0xd2, 0x05, 0xfb,
      0xe7, 0xfc, 0xf6, 0x4c, 0x29, 0xc8, 0xfd, 0x6b, 0x29, 0xb1, 0x89, 0x11,
      0xb3, 0xc5, 0xdd, 0xe1, 0x9c, 0x5a, 0xca, 0xd6, 0xca, 0x25, 0x9b, 0x29,
      0xc5, 0x5e, 0xd9, 0x1e, 0x1f, 0x89, 0x9a, 0x73, 0x18, 0x6d, 0x5d, 0x31,
      0x2a, 0x50, 0x52, 0x87, 0xf4, 0x48, 0x56, 0xba, 0x5e, 0x5f, 0xba, 0x90,
      0x98, 0x63, 0xcb, 0x15, 0xac, 0xad, 0x3e, 0x21, 0x1b, 0x17, 0x5b, 0x89,
      0xc0, 0x6c, 0xb2, 0x09, 0x57, 0x76, 0x1c, 0xcb, 0x32, 0xfa, 0x41, 0xd3,
      0xf7, 0xe3, 0x37, 0xd7, 0xf9, 0x92, 0x4b, 0x75, 0x92, 0xe0, 0x53, 0xb9,
      0x00, 0x56, 0xdb, 0xa5, 0xbf, 0x42, 0x31, 0x26, 0x15, 0xf0, 0xb5, 0xa9,
      0x87, 0x92, 0x61, 0x3f, 0x3b, 0x24, 0xf5, 0x1e, 0x94, 0xb5, 0x1c, 0xd0,
      0xcf, 0x24, 0x24, 0x50, 0x52, 0x69, 0x87, 0x1a, 0x24, 0xd1, 0x38, 0xac,
      0x3d, 0xb8, 0x51, 0xc6, 0x73, 0xd4, 0xf8, 0xae, 0x37, 0x1f, 0x41, 0xe5,
      0x00, 0xaa, 0x34, 0xf0, 0x38, 0xa1, 0xe7, 0x25, 0xe0, 0x26, 0x54, 0x38,
      0x19, 0x63, 0xa9, 0xd2, 0x19, 0x24, 0xa9, 0x05, 0x11, 0x10, 0x76, 0xa9,
      0x8f, 0x01, 0x2e, 0x97, 0x03, 0x06, 0xb6, 0x9b, 0x7d, 0xde, 0x71, 0x85,
      0x9b, 0xc5, 0xd5, 0x3e, 0xe2, 0x26, 0x5c, 0xf0, 0x67, 0x1d, 0xc3, 0x62,
      0x87, 0xb4, 0x20, 0x36, 0xd0, 0x90, 0xd5, 0xb0, 0xb7, 0xca, 0xf7, 0x89,
      0xce, 0x60, 0xa2, 0x3e, 0xf5, 0xd1, 0x5a, 0x48, 0x13, 0x50, 0x17, 0x08,
      0x5e, 0x9c, 0x98, 0x89, 0x32, 0xb4, 0x29
    };
    ubyte4 signer_rsa_crt_der_len = 1411;

    /* Read data from file */
    status = DIGICERT_readFile("openssl_certs_s2.cms", &pCMS, &cmsLen);
    retval += UNITTEST_STATUS (0, status);
    if (retval > 0)
        goto exit;

    t = MALLOC (sizeof(internal_test));
    t->bufUsed = 0;
    t->bufMax = cmsLen + 1;
    t->buf = MALLOC (t->bufMax);
    t->done = FALSE;

    cb.getCertFun = &dummyCertificateCB;
    cb.dataUpdateFun = &internal_verifyCallback;
    cb.valCertFun = &dummyVerifyCert;

    status = DIGI_CMS_newContext (&ctx,
                                 (void*)t,
                                 &cb);
    retval += UNITTEST_STATUS(10, status);
    if (retval > 0)
       goto exit;

    /* Update parser */
    status = DIGI_CMS_updateContext (ctx,
                                    pCMS, cmsLen,
                                    &finished);
    retval += UNITTEST_STATUS(11, status);
    if (retval > 0)
       goto exit;

    /* Check final status */
    retval += UNITTEST_TRUE(11, finished);
    if (retval > 0)
       goto exit;

    /* Check content type */
    status = DIGI_CMS_getContentType (ctx,
                                     &content_type);
    retval += UNITTEST_STATUS (12, status);
    if (retval > 0)
       goto exit;

    retval += UNITTEST_INT (12, content_type, E_MOC_CMS_ct_signedData);
    if (retval > 0)
        goto exit;

    /* Test that there is a certificate entry in the CMS */
    status = DIGI_CMS_getCertificates (ctx,
                                      &pCERTS, &CERTLen);
    retval += UNITTEST_STATUS (20, status);
    if (retval > 0)
       goto exit;

    retval += UNITTEST_TRUE(21, NULL != pCERTS);
    retval += UNITTEST_TRUE(21, 0 < CERTLen);
    if (retval > 0)
       goto exit;

    /* Check correct value */
    retval += UNITTEST_INT(30, CERTLen, signer_rsa_crt_der_len);
    if (retval > 0)
       goto exit;

    status = DIGI_MEMCMP (pCERTS, signer_rsa_crt_der, CERTLen, &cmpResult);
    retval += UNITTEST_STATUS (30, status);
    if (retval > 0)
       goto exit;
    retval += UNITTEST_INT(30, cmpResult, 0);

exit:
    DIGI_CMS_deleteContext (&ctx);
    if (NULL != t)
    {
        DIGI_FREE ((void**)&(t->buf));
        DIGI_FREE ((void**)&t);
    }
    DIGI_FREE ((void**)&pCMS);
    return retval;
}

int
moccms_test_testSignerData()
{
    MSTATUS status = OK;
    int retval = 0, i;

    ubyte       *pCMS = NULL;
    ubyte4      cmsLen;
    sbyte4      numSigners;

    intBoolean          finished = FALSE;
    internal_test*      t = NULL;
    MOC_CMS_context     ctx = NULL;
    MOC_CMS_Callbacks   cb = { 0 };
    MOC_CMS_ContentType content_type;

    /* Sequence with Signer Info [rfc5652 - Section 5.3, page 13] */
    MAsn1TypeAndCount defSign[10] =
    {
      {   MASN1_TYPE_SEQUENCE, 7},
        /* version:          CMSVersion */
        {   MASN1_TYPE_INTEGER, 0},
        /* sid:              SignerIdentifier */
        {   MASN1_TYPE_ENCODED, 0},
        /* digestAlgorithm:  DigestAlgorithmIdentifier */
        {   MASN1_TYPE_ENCODED, 0},
        /* signedAttrs [0] IMPLICIT: SignedAttributes OPTIONAL */
        {   MASN1_TYPE_SEQUENCE_OF | MASN1_IMPLICIT | MASN1_OPTIONAL, 1},
          {   MASN1_TYPE_ENCODED, 0},
        /* signatureAlgorithm: SignatureAlgorithmIdentifier */
        {   MASN1_TYPE_ENCODED, 0},
        /* signature:     SignatureValue */
        {   MASN1_TYPE_OCTET_STRING, 0},
        /* unsignedAttrs [1] IMPLICIT: UnsignedAttributes OPTIONAL */
        {   MASN1_TYPE_SEQUENCE_OF | MASN1_IMPLICIT | MASN1_OPTIONAL | 1, 1},
          {   MASN1_TYPE_ENCODED, 0},
    };
    MAsn1Element *pRootSign = NULL;

    /* Read data from file */
    status = DIGICERT_readFile("testfile_ummaker_s.cms", &pCMS, &cmsLen);
    retval += UNITTEST_STATUS (0, status);
    if (retval > 0)
        goto exit;

    DIGI_MALLOC ((void**)&t, sizeof(internal_test));
    t->bufUsed = 0;
    t->bufMax = cmsLen + 1;
    DIGI_MALLOC ((void**)&(t->buf), t->bufMax);
    t->done = FALSE;

    cb.getCertFun = &dummyCertificateCB;
    cb.dataUpdateFun = &internal_verifyCallback;
    cb.valCertFun = &dummyVerifyCert;

    status = DIGI_CMS_newContext (&ctx,
                                 (void*)t,
                                 &cb);
    retval += UNITTEST_STATUS(10, status);
    if (retval > 0)
       goto exit;

    /* Update parser */
    status = DIGI_CMS_updateContext (ctx,
                                    pCMS, cmsLen,
                                    &finished);
    retval += UNITTEST_STATUS(11, status);
    if (retval > 0)
       goto exit;

    /* Check final status */
    retval += UNITTEST_TRUE(11, finished);
    if (retval > 0)
       goto exit;

    /* Check content type */
    status = DIGI_CMS_getContentType (ctx,
                                     &content_type);
    retval += UNITTEST_STATUS(12, status);
    if (retval > 0)
        goto exit;

    retval += UNITTEST_INT (12, content_type, E_MOC_CMS_ct_signedData);
    if (retval > 0)
        goto exit;

    /* Test access to the two signers expected */
    status = DIGI_CMS_getNumSigners(ctx, &numSigners);
    retval += UNITTEST_STATUS (20, status);
    if (retval > 0)
        goto exit;

    retval += UNITTEST_INT(20, numSigners, 2);
    if (retval > 0)
        goto exit;

    for (i = 0; i < numSigners; ++i)
    {
        MOC_CMS_MsgSignInfo info;
        ubyte4              bytesRead;

        status = DIGI_CMS_getSignerInfo (ctx, i, &info);
        retval += UNITTEST_STATUS (30 + i, status);
        if (retval > 0)
            goto exit;

        /* Confirm expected signature size (SHA256) */
        retval += UNITTEST_INT(31 + i, info.msgSigDigestLen, 32);
        retval += UNITTEST_TRUE(31 + i, NULL != info.pMsgSigDigest);

        /* Confirm validation */
        retval += UNITTEST_TRUE(32 + i, info.verifies);

        /* Check for correct SignerInfo parsing */
        status = MAsn1CreateElementArray (defSign, 10, MASN1_FNCT_DECODE,
                                          &MAsn1OfFunction, &pRootSign);
        retval += UNITTEST_STATUS (33 + i, status);
        if (retval > 0)
            goto exit;

        status = MAsn1Decode (info.pASN1, info.ASN1Len,
                              pRootSign,
                              &bytesRead);
        retval += UNITTEST_STATUS (33 + i, status);
        if (retval > 0)
            goto exit;

        /* Read CMS Version := 1 */
        retval += UNITTEST_INT(34 + i, pRootSign[1].valueLen, 1);
        if (retval > 0)
            goto exit;
        retval += UNITTEST_INT(34 + i, pRootSign[1].value.pValue[0], 1);
        if (retval > 0)
            goto exit;

        /* Check issuer/serial data encoding length */
        retval += UNITTEST_INT(34 + i, pRootSign[2].valueLen, 205);

        /* No attributes should be present */
        retval += UNITTEST_INT(35 + i, pRootSign[5].valueLen, 0);
        retval += UNITTEST_INT(35 + i, pRootSign[9].valueLen, 0);

        /* Clean up */
        status = DIGI_CMS_deleteSignerInfo(&info);
        retval += UNITTEST_STATUS (39 + i, status);
        if (retval > 0)
            goto exit;

        MAsn1FreeElementArray (&pRootSign);
    }

exit:
    MAsn1FreeElementArray (&pRootSign);
    DIGI_CMS_deleteContext (&ctx);
    DIGI_FREE ((void**)&(t->buf));
    DIGI_FREE ((void**)&t);
    DIGI_FREE ((void**)&pCMS);
    return retval;
}
