/*
 * dh_test.c
 *
 * unit test for dh.c
 *
 * Copyright 2025 DigiCert Project Authors. All Rights Reserved.
 * 
 * DigiCert® TrustCore and TrustEdge are licensed under a dual-license model:
 * - **Open Source License**: GNU AGPL v3. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE
 * - **Commercial License**: Available under DigiCert’s Master Services Agreement. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE_COMMERCIAL.txt  
 *   or https://www.digicert.com/master-services-agreement/
 * 
 * *For commercial licensing, contact DigiCert at sales@digicert.com.*
 *
 */

#include "../dh.c"
#include "../../common/initmocana.h"
#include "../../../unit_tests/unittest.h"

#if defined( __RTOS_LINUX__) || defined(__RTOS_CYGWIN__) || defined(__RTOS_IRIX__) || defined (__RTOS_SOLARIS__) || defined (__RTOS_OPENBSD__)
#include <stdio.h>
#include <sys/types.h>
#include <sys/times.h>
#include <unistd.h>
#include <signal.h>


static volatile int mContinueTest;

#ifndef TEST_SECONDS
#define TEST_SECONDS (10)
#endif

#define START_ALARM(secs) { signal(SIGALRM, stop_test); \
                             mContinueTest = 1;          \
                             alarm(secs);                }

#define ALARM_OFF         (mContinueTest)

/*------------------------------------------------------------------*/
/* SIGALRM signal handler */
static void stop_test( int sig)
{
    sig; /* to get rid of unused warnings */
    mContinueTest = 0;
}

#endif


/*------------------------------------------------------------------*/

int DH_TestGroup(hwAccelDescr hwAccelCtx, randomContext* pRandomContext, 
                  sbyte4 groupNum, vlong** ppQueue)
{
    int retVal = 0;
    diffieHellmanContext* pContext1 = 0;
    diffieHellmanContext* pContext2 = 0;
    MSTATUS status;

    status = DH_allocateServer( MOC_DH(hwAccelCtx) pRandomContext, &pContext1, groupNum);
    retVal += UNITTEST_STATUS( groupNum, status);
    status = DH_allocateServer( MOC_DH(hwAccelCtx) pRandomContext, &pContext2, groupNum);
    retVal += UNITTEST_STATUS( groupNum, status);
    if (retVal) goto exit;

    status = VLONG_makeVlongFromVlong(COMPUTED_VLONG_F(pContext1), &COMPUTED_VLONG_E(pContext2), ppQueue);
    retVal += UNITTEST_STATUS( groupNum, status);
    status = VLONG_makeVlongFromVlong(COMPUTED_VLONG_F(pContext2), &COMPUTED_VLONG_E(pContext1), ppQueue);
    retVal += UNITTEST_STATUS( groupNum, status);
    if (retVal) goto exit;

    status = DH_computeKeyExchange(MOC_DH(hwAccelCtx) pContext1, ppQueue);
    retVal += UNITTEST_STATUS( groupNum, status);
    status = DH_computeKeyExchange(MOC_DH(hwAccelCtx) pContext2, ppQueue);
    retVal += UNITTEST_STATUS( groupNum, status);
    if (retVal) goto exit;

    retVal += UNITTEST_TRUE( groupNum, 
            0 == VLONG_compareSignedVlongs( COMPUTED_VLONG_K(pContext1), COMPUTED_VLONG_K(pContext2)));

#if defined( __RTOS_LINUX__) || defined(__RTOS_CYGWIN__) || defined(__RTOS_IRIX__) || defined (__RTOS_SOLARIS__) || defined (__RTOS_OPENBSD__)
    if (0 == retVal)
    {
        sbyte4 i;
#if defined(__USE_TOD__)
        struct rusage tstart,tend;
        long tmp;
#else
        struct tms tstart, tend;
#endif

        double diffTime;

        START_ALARM(TEST_SECONDS);

#if defined(__USE_TOD__)
        getrusage(RUSAGE_SELF, &tstart);
#else
        times(&tstart);
#endif

        for (i = 0; ALARM_OFF; ++i)
        {
            VLONG_freeVlong( &COMPUTED_VLONG_K(pContext1), ppQueue);
            DH_computeKeyExchange(MOC_DH(hwAccelCtx) pContext1, ppQueue);
        }

#if defined(__USE_TOD__)
    	getrusage(RUSAGE_SELF,&tend);
		tmp=(long)tend.ru_utime.tv_usec-(long)tstart.ru_utime.tv_usec;
		diffTime=((double)(tend.ru_utime.tv_sec-tstart.ru_utime.tv_sec))
			  +((double)tmp)/1000000.0;
#else
        times(&tend);
        diffTime = tend.tms_utime-tstart.tms_utime;
        diffTime /= sysconf(_SC_CLK_TCK);
#endif
        printf("\t%d DH key exchange (server) in %g seconds of CPU time\n", i, diffTime);
        printf("%d DH group key: %g server key exchanges/second (CPU time)\n",
               groupNum, i/diffTime);

        START_ALARM(TEST_SECONDS);

#if defined(__USE_TOD__)
        getrusage(RUSAGE_SELF, &tstart);
#else
        times(&tstart);
#endif

        for (i = 0; ALARM_OFF; ++i)
        {
            VLONG_freeVlong( &COMPUTED_VLONG_K(pContext1), ppQueue);
            VLONG_freeVlong( &COMPUTED_VLONG_F(pContext1), ppQueue);
            DH_computeKeyExchange(MOC_DH(hwAccelCtx) pContext1, ppQueue);
        }
#if defined(__USE_TOD__)
    	getrusage(RUSAGE_SELF,&tend);
		tmp=(long)tend.ru_utime.tv_usec-(long)tstart.ru_utime.tv_usec;
		diffTime=((double)(tend.ru_utime.tv_sec-tstart.ru_utime.tv_sec))
			  +((double)tmp)/1000000.0;
#else
        times(&tend);
        diffTime = tend.tms_utime-tstart.tms_utime;
        diffTime /= sysconf(_SC_CLK_TCK);
#endif
        printf("\t%d DH key exchange (client) in %g seconds of CPU time\n", i, diffTime);
        printf("%d DH group key: %g client key exchanges/second (CPU time)\n",
               groupNum, i/diffTime);

    }
#endif

exit:

    DH_freeDhContext(&pContext1, ppQueue);
    DH_freeDhContext(&pContext2, ppQueue);

    return retVal;
}

/*------------------------------------------------------------------*/

int dh_test_all()
{
    hwAccelDescr    hwAccelCtx;
    int             errcnt = 0;
    vlong*          pVlongQueue = NULL;

    /* Init digicert for the rng */
    InitMocanaSetupInfo setupInfo = {
        .MocSymRandOperator = NULL,
        .pOperatorInfo = NULL,
        /**********************************************************
         *************** DO NOT USE MOC_NO_AUTOSEED ***************
         ***************** in any production code. ****************
         **********************************************************/
        .flags = MOC_NO_AUTOSEED,
        .pStaticMem = NULL,
        .staticMemSize = 0,
        .pDigestOperators = NULL,
        .digestOperatorCount = 0,
        .pSymOperators = NULL,
        .symOperatorCount = 0,
        .pKeyOperators = NULL,
        .keyOperatorCount = 0
    };
    
    if (OK > (MSTATUS)(errcnt = DIGICERT_initialize(&setupInfo, NULL)))
        return errcnt;

    if (OK > (MSTATUS)(errcnt = HARDWARE_ACCEL_OPEN_CHANNEL(MOCANA_SSL, &hwAccelCtx)))
        goto exit;

#ifndef __ENABLE_DIGICERT_FIPS_MODULE__
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_1, &pVlongQueue);
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_2, &pVlongQueue);   
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_5, &pVlongQueue);
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_24, &pVlongQueue);
#endif
    
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_14, &pVlongQueue);     
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_15, &pVlongQueue);     
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_16, &pVlongQueue);    
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_17, &pVlongQueue);     
    errcnt += DH_TestGroup(hwAccelCtx, g_pRandomContext, DH_GROUP_18, &pVlongQueue);     

    HARDWARE_ACCEL_CLOSE_CHANNEL(MOCANA_SSL, &hwAccelCtx);
    VLONG_freeVlongQueue(&pVlongQueue);
exit:
    DIGICERT_freeDigicert();

    return errcnt;
}

/*------------------------------------------------------------------*/

static ubyte group24_xA[] = {
    0x08, 0x81, 0x38, 0x2C, 0xDB, 0x87, 0x66, 0x0C, 0x6D, 0xC1, 0x3E, 0x61, 0x49, 0x38, 0xD5, 0xB9, 0xC8, 0xB2, 0xF2, 0x48, 0x58, 0x1C, 0xC5, 0xE3, 0x1B, 0x35, 0x45, 0x43, 0x97, 0xFC, 0xE5, 0x0E
};

static ubyte group24_yA[] = {
    0x2E, 0x93, 0x80, 0xC8, 0x32, 0x3A, 0xF9, 0x75, 0x45, 0xBC, 0x49, 0x41, 0xDE, 0xB0, 0xEC, 0x37, 0x42, 0xC6, 0x2F, 0xE0, 0xEC, 0xE8, 0x24, 0xA6, 0xAB, 0xDB, 0xE6, 0x6C, 0x59, 0xBE, 0xE0, 0x24,
    0x29, 0x11, 0xBF, 0xB9, 0x67, 0x23, 0x5C, 0xEB, 0xA3, 0x5A, 0xE1, 0x3E, 0x4E, 0xC7, 0x52, 0xBE, 0x63, 0x0B, 0x92, 0xDC, 0x4B, 0xDE, 0x28, 0x47, 0xA9, 0xC6, 0x2C, 0xB8, 0x15, 0x27, 0x45, 0x42,
    0x1F, 0xB7, 0xEB, 0x60, 0xA6, 0x3C, 0x0F, 0xE9, 0x15, 0x9F, 0xCC, 0xE7, 0x26, 0xCE, 0x7C, 0xD8, 0x52, 0x3D, 0x74, 0x50, 0x66, 0x7E, 0xF8, 0x40, 0xE4, 0x91, 0x91, 0x21, 0xEB, 0x5F, 0x01, 0xC8,
    0xC9, 0xB0, 0xD3, 0xD6, 0x48, 0xA9, 0x3B, 0xFB, 0x75, 0x68, 0x9E, 0x82, 0x44, 0xAC, 0x13, 0x4A, 0xF5, 0x44, 0x71, 0x1C, 0xE7, 0x9A, 0x02, 0xDC, 0xC3, 0x42, 0x26, 0x68, 0x47, 0x80, 0xDD, 0xDC,
    0xB4, 0x98, 0x59, 0x41, 0x06, 0xC3, 0x7F, 0x5B, 0xC7, 0x98, 0x56, 0x48, 0x7A, 0xF5, 0xAB, 0x02, 0x2A, 0x2E, 0x5E, 0x42, 0xF0, 0x98, 0x97, 0xC1, 0xA8, 0x5A, 0x11, 0xEA, 0x02, 0x12, 0xAF, 0x04,
    0xD9, 0xB4, 0xCE, 0xBC, 0x93, 0x7C, 0x3C, 0x1A, 0x3E, 0x15, 0xA8, 0xA0, 0x34, 0x2E, 0x33, 0x76, 0x15, 0xC8, 0x4E, 0x7F, 0xE3, 0xB8, 0xB9, 0xB8, 0x7F, 0xB1, 0xE7, 0x3A, 0x15, 0xAF, 0x12, 0xA3,
    0x0D, 0x74, 0x6E, 0x06, 0xDF, 0xC3, 0x4F, 0x29, 0x0D, 0x79, 0x7C, 0xE5, 0x1A, 0xA1, 0x3A, 0xA7, 0x85, 0xBF, 0x66, 0x58, 0xAF, 0xF5, 0xE4, 0xB0, 0x93, 0x00, 0x3C, 0xBE, 0xAF, 0x66, 0x5B, 0x3C,
    0x2E, 0x11, 0x3A, 0x3A, 0x4E, 0x90, 0x52, 0x69, 0x34, 0x1D, 0xC0, 0x71, 0x14, 0x26, 0x68, 0x5F, 0x4E, 0xF3, 0x7E, 0x86, 0x8A, 0x81, 0x26, 0xFF, 0x3F, 0x22, 0x79, 0xB5, 0x7C, 0xA6, 0x7E, 0x29
};

static ubyte group24_xB[] = {
    0x7D, 0x62, 0xA7, 0xE3, 0xEF, 0x36, 0xDE, 0x61, 0x7B, 0x13, 0xD1, 0xAF, 0xB8, 0x2C, 0x78, 0x0D, 0x83, 0xA2, 0x3B, 0xD4, 0xEE, 0x67, 0x05, 0x64, 0x51, 0x21, 0xF3, 0x71, 0xF5, 0x46, 0xA5, 0x3D
};

static ubyte group24_yB[] = {
    0x57, 0x5F, 0x03, 0x51, 0xBD, 0x2B, 0x1B, 0x81, 0x74, 0x48, 0xBD, 0xF8, 0x7A, 0x6C, 0x36, 0x2C, 0x1E, 0x28, 0x9D, 0x39, 0x03, 0xA3, 0x0B, 0x98, 0x32, 0xC5, 0x74, 0x1F, 0xA2, 0x50, 0x36, 0x3E,
    0x7A, 0xCB, 0xC7, 0xF7, 0x7F, 0x3D, 0xAC, 0xBC, 0x1F, 0x13, 0x1A, 0xDD, 0x8E, 0x03, 0x36, 0x7E, 0xFF, 0x8F, 0xBB, 0xB3, 0xE1, 0xC5, 0x78, 0x44, 0x24, 0x80, 0x9B, 0x25, 0xAF, 0xE4, 0xD2, 0x26,
    0x2A, 0x1A, 0x6F, 0xD2, 0xFA, 0xB6, 0x41, 0x05, 0xCA, 0x30, 0xA6, 0x74, 0xE0, 0x7F, 0x78, 0x09, 0x85, 0x20, 0x88, 0x63, 0x2F, 0xC0, 0x49, 0x23, 0x37, 0x91, 0xAD, 0x4E, 0xDD, 0x08, 0x3A, 0x97,
    0x8B, 0x88, 0x3E, 0xE6, 0x18, 0xBC, 0x5E, 0x0D, 0xD0, 0x47, 0x41, 0x5F, 0x2D, 0x95, 0xE6, 0x83, 0xCF, 0x14, 0x82, 0x6B, 0x5F, 0xBE, 0x10, 0xD3, 0xCE, 0x41, 0xC6, 0xC1, 0x20, 0xC7, 0x8A, 0xB2,
    0x00, 0x08, 0xC6, 0x98, 0xBF, 0x7F, 0x0B, 0xCA, 0xB9, 0xD7, 0xF4, 0x07, 0xBE, 0xD0, 0xF4, 0x3A, 0xFB, 0x29, 0x70, 0xF5, 0x7F, 0x8D, 0x12, 0x04, 0x39, 0x63, 0xE6, 0x6D, 0xDD, 0x32, 0x0D, 0x59,
    0x9A, 0xD9, 0x93, 0x6C, 0x8F, 0x44, 0x13, 0x7C, 0x08, 0xB1, 0x80, 0xEC, 0x5E, 0x98, 0x5C, 0xEB, 0xE1, 0x86, 0xF3, 0xD5, 0x49, 0x67, 0x7E, 0x80, 0x60, 0x73, 0x31, 0xEE, 0x17, 0xAF, 0x33, 0x80,
    0xA7, 0x25, 0xB0, 0x78, 0x23, 0x17, 0xD7, 0xDD, 0x43, 0xF5, 0x9D, 0x7A, 0xF9, 0x56, 0x8A, 0x9B, 0xB6, 0x3A, 0x84, 0xD3, 0x65, 0xF9, 0x22, 0x44, 0xED, 0x12, 0x09, 0x88, 0x21, 0x93, 0x02, 0xF4,
    0x29, 0x24, 0xC7, 0xCA, 0x90, 0xB8, 0x9D, 0x24, 0xF7, 0x1B, 0x0A, 0xB6, 0x97, 0x82, 0x3D, 0x7D, 0xEB, 0x1A, 0xFF, 0x5B, 0x0E, 0x8E, 0x4A, 0x45, 0xD4, 0x9F, 0x7F, 0x53, 0x75, 0x7E, 0x19, 0x13
};

static ubyte group24_Z[]  = {
    0x86, 0xC7, 0x0B, 0xF8, 0xD0, 0xBB, 0x81, 0xBB, 0x01, 0x07, 0x8A, 0x17, 0x21, 0x9C, 0xB7, 0xD2, 0x72, 0x03, 0xDB, 0x2A, 0x19, 0xC8, 0x77, 0xF1, 0xD1, 0xF1, 0x9F, 0xD7, 0xD7, 0x7E, 0xF2, 0x25,
    0x46, 0xA6, 0x8F, 0x00, 0x5A, 0xD5, 0x2D, 0xC8, 0x45, 0x53, 0xB7, 0x8F, 0xC6, 0x03, 0x30, 0xBE, 0x51, 0xEA, 0x7C, 0x06, 0x72, 0xCA, 0xC1, 0x51, 0x5E, 0x4B, 0x35, 0xC0, 0x47, 0xB9, 0xA5, 0x51,
    0xB8, 0x8F, 0x39, 0xDC, 0x26, 0xDA, 0x14, 0xA0, 0x9E, 0xF7, 0x47, 0x74, 0xD4, 0x7C, 0x76, 0x2D, 0xD1, 0x77, 0xF9, 0xED, 0x5B, 0xC2, 0xF1, 0x1E, 0x52, 0xC8, 0x79, 0xBD, 0x95, 0x09, 0x85, 0x04,
    0xCD, 0x9E, 0xEC, 0xD8, 0xA8, 0xF9, 0xB3, 0xEF, 0xBD, 0x1F, 0x00, 0x8A, 0xC5, 0x85, 0x30, 0x97, 0xD9, 0xD1, 0x83, 0x7F, 0x2B, 0x18, 0xF7, 0x7C, 0xD7, 0xBE, 0x01, 0xAF, 0x80, 0xA7, 0xC7, 0xB5,
    0xEA, 0x3C, 0xA5, 0x4C, 0xC0, 0x2D, 0x0C, 0x11, 0x6F, 0xEE, 0x3F, 0x95, 0xBB, 0x87, 0x39, 0x93, 0x85, 0x87, 0x5D, 0x7E, 0x86, 0x74, 0x7E, 0x67, 0x6E, 0x72, 0x89, 0x38, 0xAC, 0xBF, 0xF7, 0x09,
    0x8E, 0x05, 0xBE, 0x4D, 0xCF, 0xB2, 0x40, 0x52, 0xB8, 0x3A, 0xEF, 0xFB, 0x14, 0x78, 0x3F, 0x02, 0x9A, 0xDB, 0xDE, 0x7F, 0x53, 0xFA, 0xE9, 0x20, 0x84, 0x22, 0x40, 0x90, 0xE0, 0x07, 0xCE, 0xE9,
    0x4D, 0x4B, 0xF2, 0xBA, 0xCE, 0x9F, 0xFD, 0x4B, 0x57, 0xD2, 0xAF, 0x7C, 0x72, 0x4D, 0x0C, 0xAA, 0x19, 0xBF, 0x05, 0x01, 0xF6, 0xF1, 0x7B, 0x4A, 0xA1, 0x0F, 0x42, 0x5E, 0x3E, 0xA7, 0x60, 0x80,
    0xB4, 0xB9, 0xD6, 0xB3, 0xCE, 0xFE, 0xA1, 0x15, 0xB2, 0xCE, 0xB8, 0x78, 0x9B, 0xB8, 0xA3, 0xB0, 0xEA, 0x87, 0xFE, 0xBE, 0x63, 0xB6, 0xC8, 0xF8, 0x46, 0xEC, 0x6D, 0xB0, 0xC2, 0x6C, 0x5D, 0x7C
};

/*------------------------------------------------------------------*/

int dh_test_rfc5114_group24()
{
    int                     retVal = 0;
    
#ifndef __ENABLE_DIGICERT_FIPS_MODULE__
    /* test for RFC-511 */
    MSTATUS                 status;
    diffieHellmanContext*   p_dhContext = NULL;
    vlong*                  pZ = NULL;
    hwAccelDescr            hwAccelCtx;
    vlong*                  pVlongQueue = NULL;

    status = HARDWARE_ACCEL_OPEN_CHANNEL(MOCANA_SSL, &hwAccelCtx);
    if (UNITTEST_STATUS(0, status))   
    {
        return 1;
    }

    status = VLONG_vlongFromByteString(group24_Z, sizeof(group24_Z), &pZ, &pVlongQueue);
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = DH_allocate(&p_dhContext);
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = DH_getG(DH_GROUP_24, &COMPUTED_VLONG_G(p_dhContext));
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = DH_getP(DH_GROUP_24, &COMPUTED_VLONG_P(p_dhContext));
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = VLONG_vlongFromByteString(group24_xA, sizeof(group24_xA), 
                    &COMPUTED_VLONG_Y(p_dhContext), &pVlongQueue);
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = VLONG_vlongFromByteString(group24_yB, sizeof(group24_yB), 
                    &COMPUTED_VLONG_E(p_dhContext), &pVlongQueue);
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    status = DH_computeKeyExchange(MOC_DH(hwAccelCtx) p_dhContext, &pVlongQueue);
    UNITTEST_STATUS_GOTO( 0, status, retVal, exit);

    retVal += UNITTEST_TRUE(0, 0 == VLONG_compareSignedVlongs(pZ, COMPUTED_VLONG_K(p_dhContext)));

exit:

    VLONG_freeVlong(&pZ, 0);
    DH_freeDhContext( &p_dhContext, 0);
    VLONG_freeVlongQueue(&pVlongQueue);
    HARDWARE_ACCEL_CLOSE_CHANNEL(MOCANA_SSL, &hwAccelCtx);

#endif

    return retVal;
}
