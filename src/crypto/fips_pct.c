/*
 * fips_pct.c
 *
 * FIPS 140-3 Self Test Compliance
 *
 * Copyright 2025 DigiCert Project Authors. All Rights Reserved.
 * 
 * DigiCert® TrustCore and TrustEdge are licensed under a dual-license model:
 * - **Open Source License**: GNU AGPL v3. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE
 * - **Commercial License**: Available under DigiCert’s Master Services Agreement. See: https://github.com/digicert/trustcore-test/blob/main/LICENSE_COMMERCIAL.txt  
 *   or https://www.digicert.com/master-services-agreement/
 * 
 * *For commercial licensing, contact DigiCert at sales@digicert.com.*
 *
 */

#include "../common/moptions.h"

#ifdef __ENABLE_MOCANA_FIPS_MODULE__
#ifdef __ENABLE_MOCANA_FIPS_LEGACY_PCT__

#include "../common/mtypes.h"
#include "../common/mocana.h"
#include "../crypto/hw_accel.h"
#include "../common/mdefs.h"
#include "../common/merrors.h"
#include "../common/mrtos.h"
#include "../common/mstdlib.h"
#include "../common/vlong.h"
#include "../common/random.h"
#include "../common/debug_console.h"
#include "../common/memory_debug.h"
#include "../crypto/crypto.h"
#include "../crypto/aes.h"
#include "../crypto/aes_ecb.h"
#include "../crypto/aes_ctr.h"
#include "../crypto/aes_ccm.h"
#include "../crypto/aes_cmac.h"
#include "../crypto/aes_xts.h"
#include "../crypto/gcm.h"
#include "../crypto/des.h"
#include "../crypto/three_des.h"
#include "../crypto/md5.h"
#include "../crypto/sha1.h"
#include "../crypto/sha256.h"
#include "../crypto/sha512.h"
#include "../crypto/sha3.h"
#include "../crypto/hmac.h"
#include "../crypto/hmac_kdf.h"
#include "../crypto/dh.h"
#include "../crypto/rsa.h"
#include "../crypto/dsa.h"
#ifdef __ENABLE_MOCANA_ECC__
#include "../crypto/primefld.h"
#include "../crypto/primefld_priv.h"
#include "../crypto/primeec.h"
#include "../crypto/ecc.h"
#ifdef __ENABLE_MOCANA_ECC_ED_COMMON__
#include "../crypto/ecc_edwards.h"
#endif
#endif /* __ENABLE_MOCANA_ECC__ */
#include "../crypto/nist_rng.h"
#include "../crypto/fips.h"
#include "../crypto/fips_priv.h"
#include "../harness/harness.h"


#if defined(__RTOS_LINUX__) || defined(__RTOS_ANDROID__)
#ifndef __ENABLE_MOCANA_CRYPTO_KERNEL_MODULE_FIPS__
#include <stdio.h>
#define __MOCANA_LINUX_SHARED_LIBRARY__
#else
#include <linux/string.h>
#include <linux/slab.h>
#endif
#endif

#ifdef __RTOS_VXWORKS__
#include <stdio.h>
#endif

#ifdef __RTOS_WIN32__
#include <stdio.h>
/* Conflicts w/ def in WinNT.h */
#ifdef CR
#undef CR
#endif
#include <Windows.h>
#include <string.h>
#include <tchar.h>
#endif

#ifdef __RTOS_WINCE__
#include <stdio.h>
#include <windows.h>
#include <string.h>
#include <tchar.h>
#endif

MOC_EXTERN volatile FIPSStartupStatus sCurrStatus; /* What has passed (or not). */

#if (!defined(__ENABLE_MOCANA_CRYPTO_KERNEL_MODULE_FIPS__))

#if (defined(__ENABLE_MOCANA_DSA__))
static const
ubyte m_dsaKeyBlob[] =
{
  0x00, 0x00, 0x01, 0x01, 0x00, 0x82, 0xc4, 0xcb, 0x18, 0x3e, 0x37, 0x46,
  0x13, 0x30, 0x13, 0xd8, 0x90, 0x35, 0x51, 0xb4, 0xd2, 0x6b, 0x8b, 0x71,
  0x71, 0x0a, 0x32, 0xb5, 0x9f, 0x3c, 0x55, 0x49, 0x25, 0x90, 0x79, 0x11,
  0x92, 0xfb, 0xaf, 0x9e, 0x68, 0x51, 0x0d, 0x60, 0x99, 0x5d, 0x37, 0xc8,
  0x01, 0x78, 0x49, 0x13, 0xba, 0x66, 0x69, 0xb7, 0xfc, 0xfc, 0xaa, 0x02,
  0xa1, 0xa3, 0x8b, 0xe9, 0x65, 0x9f, 0x77, 0x9c, 0xad, 0x30, 0x97, 0x62,
  0x30, 0x8b, 0x65, 0x9b, 0xa2, 0xd6, 0x40, 0xda, 0xf2, 0x45, 0x49, 0x3f,
  0x1b, 0xa3, 0x92, 0xa8, 0xd6, 0xe8, 0x11, 0x18, 0x26, 0x94, 0x52, 0x16,
  0x11, 0xfa, 0x27, 0x62, 0x80, 0x8b, 0xf8, 0x6a, 0xca, 0x8d, 0x4a, 0x07,
  0x5c, 0x84, 0xb5, 0x3f, 0x66, 0x4e, 0xe3, 0x02, 0x56, 0x66, 0x32, 0x7a,
  0x76, 0x93, 0x7c, 0xd4, 0xad, 0xaa, 0xef, 0xf0, 0xae, 0x9c, 0x48, 0x0c,
  0xda, 0x63, 0x2a, 0xd5, 0x8a, 0x69, 0x07, 0x3e, 0x71, 0x5a, 0x92, 0x00,
  0xd3, 0x87, 0x5c, 0x67, 0x71, 0x33, 0x13, 0xff, 0xd4, 0x26, 0x12, 0xaf,
  0x85, 0x09, 0x21, 0x40, 0x8f, 0x0e, 0x72, 0xdc, 0x45, 0xe3, 0x4e, 0x03,
  0xf8, 0xa9, 0xc4, 0x82, 0x31, 0xe8, 0x36, 0xa2, 0x75, 0x29, 0xcf, 0x2c,
  0xe3, 0x40, 0x4d, 0x0d, 0x93, 0xb9, 0xd0, 0x27, 0xb6, 0x82, 0x32, 0x6a,
  0xc2, 0x11, 0x85, 0x57, 0xad, 0x83, 0xe5, 0x4c, 0xca, 0x3a, 0x9e, 0xe4,
  0x13, 0x61, 0x14, 0x26, 0x11, 0x0e, 0x75, 0x0a, 0x70, 0xed, 0xe3, 0x20,
  0x02, 0xce, 0x5f, 0xea, 0x71, 0xbd, 0xc1, 0x0c, 0xe2, 0xa2, 0xed, 0x63,
  0x3a, 0xc2, 0x07, 0xd6, 0x72, 0x82, 0x36, 0x65, 0x23, 0x8f, 0x91, 0x13,
  0x10, 0xfe, 0x42, 0x52, 0x19, 0xfc, 0xfe, 0x64, 0x67, 0xf6, 0xc1, 0xd5,
  0x46, 0x63, 0x20, 0x9b, 0xaa, 0xaa, 0x01, 0x22, 0x53, 0x00, 0x00, 0x00,
  0x21, 0x00, 0xc0, 0x8e, 0x7e, 0xcc, 0xed, 0x16, 0xfa, 0x6d, 0x00, 0x2e,
  0x3f, 0x03, 0x85, 0x46, 0x58, 0x46, 0xb5, 0xd9, 0xc3, 0xaa, 0x72, 0x99,
  0x4a, 0x80, 0x55, 0x9e, 0xbc, 0x62, 0xfc, 0xae, 0x2f, 0x7b, 0x00, 0x00,
  0x01, 0x00, 0x14, 0x0b, 0x51, 0x8c, 0x8b, 0x28, 0x00, 0xf2, 0x5a, 0x0d,
  0x9b, 0x5b, 0x84, 0xe1, 0x43, 0x60, 0x6a, 0xe9, 0xd4, 0x23, 0x4a, 0xd2,
  0xbb, 0x34, 0xab, 0xa9, 0xe7, 0xe4, 0xf1, 0xfe, 0x25, 0xd5, 0xfe, 0xf4,
  0x09, 0x2f, 0x1e, 0xb9, 0x11, 0x31, 0x5f, 0x2f, 0xdf, 0xbd, 0xe5, 0x73,
  0x3d, 0xaa, 0x62, 0x5f, 0xb5, 0x06, 0x6e, 0x03, 0xde, 0xe1, 0xae, 0x24,
  0x97, 0xb0, 0x30, 0x36, 0x14, 0x9f, 0x3f, 0x18, 0xd4, 0xf8, 0x0c, 0x06,
  0x5b, 0xfa, 0x84, 0x52, 0xfb, 0xa2, 0xc2, 0x1d, 0x36, 0x4e, 0xbf, 0x68,
  0xc2, 0x36, 0xba, 0xad, 0x79, 0xc3, 0xb2, 0x35, 0x00, 0xac, 0x00, 0x2f,
  0xc7, 0x5e, 0x3d, 0xd1, 0x41, 0x82, 0x85, 0x62, 0xf6, 0x3f, 0xeb, 0x43,
  0x6e, 0xa3, 0x73, 0x35, 0x99, 0x8e, 0xde, 0xb0, 0xc7, 0xde, 0x50, 0x10,
  0x58, 0xb5, 0x14, 0x50, 0x58, 0x51, 0xfe, 0x82, 0x63, 0x90, 0x07, 0x91,
  0x1f, 0xa7, 0xe2, 0xd3, 0x86, 0xf0, 0x7c, 0x1c, 0x2a, 0x8a, 0x47, 0xc6,
  0x35, 0x74, 0x12, 0xd1, 0x0a, 0xf0, 0x6f, 0x3b, 0x27, 0x91, 0x09, 0x20,
  0x5f, 0x05, 0xeb, 0x24, 0xd9, 0x73, 0x0d, 0xdd, 0xc8, 0x5a, 0xde, 0xe5,
  0x8e, 0xe9, 0xdf, 0x31, 0x28, 0x5c, 0xf4, 0x21, 0xc9, 0x60, 0x6e, 0x51,
  0x2e, 0x13, 0xef, 0x88, 0x38, 0xd1, 0xdc, 0x7a, 0x04, 0x45, 0x66, 0x06,
  0xd2, 0x53, 0xf0, 0x8c, 0x0d, 0x0d, 0xb4, 0xb6, 0xc2, 0x2d, 0x37, 0x31,
  0xa7, 0x9b, 0x4a, 0x44, 0x2a, 0x2a, 0x8c, 0xa8, 0x4d, 0x70, 0x59, 0xb6,
  0x72, 0x51, 0x99, 0x11, 0xe6, 0xc3, 0x4f, 0x83, 0xa5, 0xdf, 0x32, 0x3c,
  0x50, 0x3a, 0x5f, 0xe3, 0x51, 0x5f, 0xc4, 0xb8, 0xec, 0x5f, 0xbb, 0x6c,
  0x6f, 0x5f, 0x01, 0xb6, 0xfd, 0x00, 0x23, 0x59, 0xaa, 0x5d, 0xe6, 0x55,
  0x02, 0xa9, 0x5f, 0x92, 0xca, 0xd3, 0x00, 0x00, 0x01, 0x00, 0x08, 0x77,
  0xd0, 0x6c, 0x5b, 0xc3, 0x51, 0x67, 0x64, 0x6c, 0x19, 0xc2, 0x31, 0xe4,
  0x67, 0xb6, 0x17, 0x5c, 0x4c, 0xb8, 0xb4, 0x27, 0xde, 0x81, 0xca, 0x2f,
  0x17, 0x30, 0x92, 0xfd, 0x69, 0xd6, 0xf7, 0xd9, 0xa5, 0x11, 0x98, 0x41,
  0x6f, 0xc4, 0xe8, 0x98, 0x25, 0xfe, 0x71, 0x5e, 0xbd, 0x24, 0x68, 0x14,
  0xc6, 0xcd, 0x17, 0xbe, 0x2c, 0xd6, 0xf0, 0xef, 0xe6, 0x2d, 0xd4, 0xc0,
  0xad, 0x0c, 0x78, 0xfe, 0x7d, 0xe4, 0x8b, 0xde, 0x9f, 0xb0, 0xbc, 0x6d,
  0x03, 0x83, 0x3a, 0x14, 0xe4, 0xb8, 0x0d, 0xc6, 0xbc, 0x85, 0xbb, 0xe2,
  0xb3, 0xa3, 0x17, 0x20, 0xf9, 0xce, 0x83, 0xe7, 0x82, 0x9f, 0x57, 0xfb,
  0xc1, 0x13, 0x91, 0xb8, 0x55, 0xe2, 0x85, 0x52, 0x5b, 0x06, 0x24, 0xa0,
  0x6f, 0x2a, 0xc7, 0xad, 0x66, 0xc5, 0x66, 0xfe, 0xc1, 0x6c, 0x02, 0x38,
  0x00, 0x03, 0x2a, 0x73, 0x89, 0x3d, 0x8f, 0x36, 0x59, 0x3e, 0x1c, 0xf0,
  0x62, 0x27, 0x45, 0xa2, 0xa5, 0xf8, 0x51, 0x4b, 0x60, 0x21, 0xb5, 0xed,
  0xeb, 0xe0, 0x79, 0x54, 0x43, 0xe0, 0xb2, 0x91, 0xbf, 0xe9, 0x2b, 0x78,
  0xd3, 0xa2, 0xf8, 0x31, 0x7c, 0x06, 0xdb, 0x0c, 0xbc, 0x32, 0xe4, 0x71,
  0x9d, 0xcf, 0x2a, 0x79, 0xda, 0x47, 0x16, 0xba, 0x27, 0x73, 0x75, 0xd8,
  0xb4, 0xdc, 0x1d, 0x1e, 0xd2, 0xfb, 0xdd, 0xac, 0x8b, 0xa5, 0x76, 0xab,
  0x48, 0x92, 0x68, 0xc2, 0x59, 0xe2, 0x71, 0x03, 0x61, 0x4e, 0x5f, 0x85,
  0x19, 0x43, 0xa6, 0x0e, 0xf7, 0x28, 0x17, 0xc3, 0xec, 0xe4, 0x2b, 0xc6,
  0xb1, 0x3e, 0xcb, 0x9c, 0x91, 0xb8, 0xf2, 0x4e, 0xcd, 0xaf, 0xfb, 0x63,
  0x15, 0xe9, 0xcc, 0xc1, 0x2e, 0x4f, 0xb3, 0xf3, 0x5d, 0x6a, 0xb8, 0x01,
  0xc1, 0x97, 0xc0, 0x03, 0x29, 0xe3, 0x60, 0x28, 0x74, 0x0d, 0x63, 0xc5,
  0x91, 0x49, 0x00, 0x00, 0x00, 0x20, 0x64, 0x86, 0xce, 0x78, 0xc9, 0x9a,
  0x81, 0x58, 0x9e, 0xff, 0x46, 0xc9, 0x0a, 0x70, 0x7f, 0x1b, 0x1e, 0x8e,
  0x7c, 0x48, 0xf8, 0x29, 0x40, 0x01, 0x7e, 0x8b, 0x0b, 0x4b, 0x65, 0xa6,
  0xf1, 0x8e
};

/*------------------------------------------------------------------*/

static MSTATUS
FIPS_pctDsaTest(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    DSAKey*         pDSAKey = NULL;
    DSAKey*         pDerivedDSAKey = NULL;
    vlong*          pH  = NULL;
    char*           pData = "Attack at dawn";
    vlong*          pBuff = NULL;
    vlong*          pR = NULL;
    vlong*          pS = NULL;
    intBoolean      isGoodSig = FALSE;
    MSTATUS         status = OK;

    if (OK > (status = DSA_extractKeyBlob(&pDerivedDSAKey, m_dsaKeyBlob, sizeof(m_dsaKeyBlob))))
        goto exit;

    /* Converting the message string to VLONG */
    if (OK > (status = VLONG_vlongFromByteString((const ubyte*)pData, MOC_STRLEN((sbyte*)pData), &pBuff, NULL)))
        goto exit;

    /* Compute the Signature */
    if (OK > (status = DSA_computeSignature(MOC_DSA(hwAccelCtx)
                                            pRandomContext, pDerivedDSAKey,
                                            pBuff, &isGoodSig,
                                            &pR, &pS, NULL)))
    {
        goto exit;
    }

    if (FALSE == isGoodSig)
    {
        status = ERR_FIPS_DSA_FAIL;
        goto exit;
    }

    if (FIPS_FORCE_FAIL_DSA_TEST)
    {
        *(pR->pUnits) ^= 0x783F;
    }

    /* Verify the signature */
    if (OK > (status = DSA_verifySignature(MOC_DSA(hwAccelCtx)
                                           pDerivedDSAKey, pBuff,
                                           pR, pS,
                                           &isGoodSig, NULL)))
    {
        goto exit;
    }

    if (FALSE == isGoodSig)
    {
        status = ERR_FIPS_DSA_FAIL;
        goto exit;
    }

    DSA_freeKey(&pDSAKey,NULL);
    DSA_freeKey(&pDerivedDSAKey,NULL);
    VLONG_freeVlong(&pH,NULL);
    VLONG_freeVlong(&pR,NULL);
    VLONG_freeVlong(&pS,NULL);
    VLONG_freeVlong(&pBuff,NULL);

exit:
    return status;
}

/*------------------------------------------------------------------*/

MOC_EXTERN MSTATUS
FIPS_dsaPct(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    MSTATUS status = OK;

#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_startTestMsg("FIPS_dsaPct", "DSA");
#endif

    if (OK > (status = FIPS_pctDsaTest(hwAccelCtx, pRandomContext)))
        goto exit;

exit:
#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_endTestMsg("FIPS_dsaPct", "DSA", status);
#endif

    setFIPS_Status_Once(FIPS_ALGO_DSA, status);
    return status;
}
#endif /* (defined(__ENABLE_MOCANA_DSA__)) */

/*------------------------------------------------------------------*/

#if (defined(__ENABLE_MOCANA_ECC__))
/* P224 data */
static const ubyte gpP224priv[28] =
{
    0x53,0x95,0xFC,0x8C,0xF7,0x48,0xC9,0x75,0x31,0x0A,0x2A,0xE5,0xCB,0x47,0x97,0x2F,
    0xFC,0xD8,0x5F,0x2F,0x52,0xE3,0x78,0x20,0x5F,0x22,0x11,0x48
};

static const ubyte gpP224pubX[28] =
{
    0x5C,0x02,0x54,0xFC,0xB8,0x4D,0xC1,0xEF,0x47,0x2A,0x9B,0x27,0x50,0xD3,0x10,0x6A,
    0xC4,0x02,0xC7,0x2D,0x1F,0x9A,0x5D,0xBC,0x50,0xF9,0xB7,0xF5
};

static const ubyte gpP224pubY[28] =
{
    0x52,0x19,0xF9,0x98,0x1B,0x3F,0xF9,0x0A,0xE2,0xDC,0x7F,0x36,0xFD,0x7F,0x5C,0xF0,
    0x0D,0x7D,0x1B,0x15,0xAE,0x8B,0x54,0x7D,0xDA,0xEC,0xA5,0x36
};

/*------------------------------------------------------------------*/

static MSTATUS FIPS_getECDSAKey224(ECCKey *pKey)
{
    MSTATUS status = OK;
    PrimeFieldPtr pPF = EC_getUnderlyingField(pKey->pCurve);

    status = PRIMEFIELD_setToByteString(pPF, pKey->k, gpP224priv, sizeof(gpP224priv));
    if (OK != status)
        goto exit;

    status = PRIMEFIELD_setToByteString(pPF, pKey->Qx, gpP224pubX, sizeof(gpP224pubX));
    if (OK != status)
        goto exit;

    status = PRIMEFIELD_setToByteString(pPF, pKey->Qy, gpP224pubY, sizeof(gpP224pubY));

exit:

    return status;
}

/*------------------------------------------------------------------*/

static MSTATUS
FIPS_pctEcdsaTest(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    PFEPtr              r       = NULL;
    PFEPtr              s       = NULL;
    PrimeFieldPtr       pPF     = NULL;
    ECCKey*             pNewKey = NULL;
    MSTATUS             status  = OK;

    const ubyte hash[28] =
    {
      0xFB,0x55,0x3D,0xE7,0x46,0xCE,0x92,0xEB,0x85,0x61,0x08,0xBA,0xAC,0x5C,0x83,0xFA,
      0x7E,0x09,0x0A,0xCD,0xEE,0xA7,0x6C,0xB6,0x01,0xE8,0xCC,0xED
    };
    ubyte4 hashLen = 28;

    if (OK > (status = EC_newKey(EC_P224, &pNewKey)))
        goto exit;

    if (OK > (status = FIPS_getECDSAKey224(pNewKey)))
        goto exit;

    pPF = EC_getUnderlyingField(pNewKey->pCurve);

    if (OK > (status = PRIMEFIELD_newElement(pPF, &r)))
        goto exit;

    if (OK > (status = PRIMEFIELD_newElement(pPF, &s)))
        goto exit;

    if (OK > (status = ECDSA_signDigestAux(pNewKey->pCurve, pNewKey->k, RANDOM_rngFun,
                                  pRandomContext, hash, hashLen, r, s)))
    {
        goto exit;
    }

    if (FIPS_FORCE_FAIL_ECDSA_TEST)
    {
        r->units[0] ^= 0x783F;
    }

    if (OK > (status = ECDSA_verifySignature(pNewKey->pCurve,
                                             pNewKey->Qx, pNewKey->Qy, hash, hashLen,
                                             r, s)))
    {
        goto exit;
    }

    /* do a negative test */
    if (OK <= (status = ECDSA_verifySignature(pNewKey->pCurve,
                                              pNewKey->Qx, pNewKey->Qy, hash, hashLen - 1,
                                              r, s)))
    {
        status = ERR_FIPS_ECDSA_PCT_FAILED;
        goto exit;
    }

    status = OK;

exit:
    PRIMEFIELD_deleteElement(pPF, &r);
    PRIMEFIELD_deleteElement(pPF, &s);

    EC_deleteKey(&pNewKey);
    return status;
}

/*------------------------------------------------------------------*/

MOC_EXTERN MSTATUS
FIPS_ecdsaPct(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    MSTATUS status = OK;

#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_startTestMsg("FIPS_ecdsaPct", "ECDSA-P224");
#endif

    if (OK > (status = FIPS_pctEcdsaTest(hwAccelCtx, pRandomContext)))
        goto exit;

exit:
#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_endTestMsg("FIPS_ecdsaPct", "ECDSA-P224", status);
#endif

    setFIPS_Status_Once(FIPS_ALGO_ECC, status);  /* There is overlap. */
    setFIPS_Status_Once(FIPS_ALGO_ECDSA, status);

    return status;
}
#endif /* (defined(__ENABLE_MOCANA_ECC__)) */

/*---------------------------------------------------------------------------*/

#ifdef __ENABLE_MOCANA_FIPS_EDDSA__
#if (defined(__ENABLE_MOCANA_ECC_EDDSA__))
static ubyte gpP25519priv[32] =
{
    0x83,0x3f,0xe6,0x24,0x09,0x23,0x7b,0x9d,0x62,0xec,0x77,0x58,0x75,0x20,0x91,0x1e,
    0x9a,0x75,0x9c,0xec,0x1d,0x19,0x75,0x5b,0x7d,0xa9,0x01,0xb9,0x6d,0xca,0x3d,0x42
};

static ubyte gpP25519pub[32] =
{
    0xec,0x17,0x2b,0x93,0xad,0x5e,0x56,0x3b,0xf4,0x93,0x2c,0x70,0xe1,0x24,0x50,0x34,
    0xc3,0x54,0x67,0xef,0x2e,0xfd,0x4d,0x64,0xeb,0xf8,0x19,0x68,0x34,0x67,0xe2,0xbf
};

static MSTATUS FIPS_getEDDSAKey25519(edECCKey *pKey)
{
    MSTATUS status = OK;

    status = edECC_setKeyParameters(pKey, gpP25519pub, sizeof(gpP25519pub),
        gpP25519priv, sizeof(gpP25519priv), NULL, NULL);
     if (OK != status)
         goto exit;

exit:
    return status;
}

#endif /* (defined(__ENABLE_MOCANA_ECC_EDDSA__)) */

/*---------------------------------------------------------------------------*/

#if (defined(__ENABLE_MOCANA_ECC_EDDSA__))
static MSTATUS
FIPS_pctEddsaTest(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    MSTATUS status  = OK;
    ubyte4 verifyStatus  = 0;
    edECCKey* pNewKey = NULL;
    BulkHashAlgo shaSuite = {0};
    ubyte pSignature[57*2] = {0}; /* big enough for either curve */
    ubyte4 signatureLen;

    const ubyte mesg[] =
    {
      0xD1,0x1C,0xA5,0xB4,0xC0,0xE6,0x10,0xD8,0x4B,0x14,0xCF,0xED,0x38,0xFF,0x64,0x58
    };

    ubyte4 mesgLen = 16;

    status = CURVE25519_createCombMutex();
    if (OK != status)
    {
         goto exit;
    }

    status = CURVE448_createCombMutex();
    if (OK != status)
    {
         goto exit;
    }

    status = edECC_newKey(&pNewKey, curveEd25519, NULL);
    if (OK != status)
        goto exit;

    if (OK > (status = FIPS_getEDDSAKey25519(pNewKey)))
        goto exit;

    shaSuite.allocFunc = &SHA512_allocDigest;
    shaSuite.initFunc = (BulkCtxInitFunc) &SHA512_initDigest;
    shaSuite.updateFunc = (BulkCtxUpdateFunc) &SHA512_updateDigest;
    shaSuite.finalFunc = (BulkCtxFinalFunc) &SHA512_finalDigest;
    shaSuite.freeFunc = &SHA512_freeDigest;
    shaSuite.digestFunc = NULL;

    status = edDSA_Sign(pNewKey, (ubyte *) mesg, mesgLen, pSignature,
        sizeof(pSignature), &signatureLen, &shaSuite, FALSE, NULL, 0, NULL);
    if (OK != status)
    {
         goto exit;
    }

    if (FIPS_FORCE_FAIL_EDDSA_TEST)
    {
        pSignature[0] ^= 0x783F;
    }

    pNewKey->isPrivate = FALSE;
    status = edDSA_VerifySignature(pNewKey, mesg, mesgLen, pSignature,
        signatureLen, &verifyStatus, &shaSuite, FALSE, NULL, 0, NULL);
    if (OK != verifyStatus)
    {
         status = ERR_FALSE;
         goto exit;
    }

    /* do a negative test */
    status= edDSA_VerifySignature(pNewKey, mesg, mesgLen - 1, pSignature,
        signatureLen, &verifyStatus, &shaSuite, FALSE, NULL, 0, NULL);
    if(1 != verifyStatus)
    {
        status = ERR_CRYPTO;
        goto exit;
    }
    status = OK;

exit:
    if (NULL != pNewKey)
    {
        edECC_deleteKey(&pNewKey, NULL);
    }

    return status;
}

/*---------------------------------------------------------------------------*/

MOC_EXTERN MSTATUS
FIPS_eddsaPct(hwAccelDescr hwAccelCtx, randomContext *pRandomContext)
{
    MSTATUS status = OK;

#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_startTestMsg("FIPS_eddsaPct", "ED-25519");
#endif

    if (OK > (status = FIPS_pctEddsaTest(hwAccelCtx, pRandomContext)))
        goto exit;

exit:
#ifdef __ENABLE_MOCANA_FIPS_STATUS_MESSAGES__
    FIPS_endTestMsg("FIPS_eddsaPct", "ED-25519", status);
#endif

    setFIPS_Status_Once(FIPS_ALGO_EDDSA, status);

    return status;
}
#endif /* (defined(__ENABLE_MOCANA_ECC_EDDSA__)) */
#endif /* (defined(__ENABLE_MOCANA_FIPS_EDDSA__)) */

/*---------------------------------------------------------------------------*/

#endif /* !defined(__ENABLE_MOCANA_CRYPTO_KERNEL_MODULE_FIPS__)) */

#endif /* __ENABLE_MOCANA_FIPS_LEGACY_PCT__ */
#endif /* __ENABLE_MOCANA_FIPS_MODULE__ */

